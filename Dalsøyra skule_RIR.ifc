Properties of the parts of a building model (IFC2X3), part 7 of 14

# IfcCovering: BIB.021 (1891)
Name | In | MagiCAD Pset_Pipe, User Code | MagiCAD Pset_Pipe, Manufacturer | ConnectionSize_DN | Insulation_thickness_mm | SystemType | SystemName | SystemClass | MagiCAD Pset_Pipe, Insulation Material Code
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 250.341; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 604.042; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 181.536; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.7; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 717.892; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 6.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 246.33; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 37.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 36.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 263.846; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 808.429; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 189.349; Material Code: MM
2 x BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 36.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.7; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 670.545; Material Code: MM
2 x BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 7.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 125.073; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 36.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 161.119; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 7.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 219.308; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 25-25 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 7.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 100.266; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 25-25 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 36.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 576.024; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 395.7; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 25-25 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 38.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 161.105; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 25-25 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 38.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 39.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 119.638; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 4.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 352.061; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 7.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 104.58; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 7.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 272.325; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 328.38; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 36.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 135.462; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 36.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 85.756; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 36.9; dpTot_SizingFlow_kPa [kPa]: 29.6; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 7.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 129.099; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 487.676; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 7.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 36.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 174.486; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 36.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 435.43; Material Code: MM
2 x BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 8.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 181.791; Material Code: MM
3 x BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 36.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 59.542; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 36.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 46.718; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 8.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 187.606; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 8.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 86.607; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.6; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 585.36; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 8.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 35.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 214.299; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 35.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 451.465; Material Code: MM
2 x BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 8.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 35.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 173.534; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 35.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 39.941; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 685.038; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 93.276; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 348.94; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.2; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1146.587; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 36.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 791.587; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 36.895; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 27.5; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 54.724; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 51.164; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 9.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 309.382; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 9.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 35.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 80.756; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 35.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 614.081; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 35.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 612.64; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 8.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 35.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 179.846; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 35.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 757.441; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 8.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 159.602; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 36.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 148.371; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 400.608; Material Code: MM
3 x BIB.021 | Havnivå |  |  | 18-15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 18-15; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå |  |  | 18-15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 18-15; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
2 x BIB.021 | Havnivå |  |  | 28-22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 28-22; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
2 x BIB.021 | Havnivå |  |  | 50-42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 50-42; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå |  |  | 32-28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 32-28; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå |  |  | 32-28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 32-28; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
2 x BIB.021 | Havnivå |  |  | 50-42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 50-42; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå |  | Generic | 65-50 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - Description: MagiCAD - default reduction; ConnectionSize: 65-50; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB3
4 x BIB.021 | Havnivå |  |  | 20-18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 20-18; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
4 x BIB.021 | Havnivå |  |  | 20-18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 20-18; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
6 x BIB.021 | Havnivå |  |  | 25-22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 25-22; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
6 x BIB.021 | Havnivå |  |  | 25-22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 25-22; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
2 x BIB.021 | Havnivå |  |  | 28-18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 28-18; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå |  |  | 28-22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 28-22; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
2 x BIB.021 | Havnivå |  |  | 22-18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 22-18; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå |  |  | 22-18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 22-18; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
2 x BIB.021 | Havnivå |  |  | 42-35 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 42-35; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
2 x BIB.021 | Havnivå |  |  | 42-35 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 42-35; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå |  |  | 28-18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 28-18; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå |  |  | 28-15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 28-15; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 1.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 924.978; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 43.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1050.917; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 43.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1600; Material Code: MM DN
BIB.021 | Havnivå |  |  | 54-50 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 54-50; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå |  | Generic | 65-50 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - Description: MagiCAD - default reduction; ConnectionSize: 65-50; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB3
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 81.417; Material Code: MM
BIB.021 | Havnivå | SVZ.001 | IMI Hydronic Engineering | 15-15 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Innreguleringsventil DN 10-50; User Code: SVZ.001; Manufacturer: IMI Hydronic Engineering; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 5.3; dpTot_SizingFlow_kPa [kPa]: 4.5; Product Code: STAD/F-15/14; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SVZ; Product variable 2: 001; Product variable 4: 4; NationalCode: UC2.123102112
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 260.447; Material Code: MM
BIB.021 | Havnivå | SVZ.001 | IMI Hydronic Engineering | 15-15 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Innreguleringsventil DN 10-50; User Code: SVZ.001; Manufacturer: IMI Hydronic Engineering; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 5.3; dpTot_SizingFlow_kPa [kPa]: 3.0; Product Code: STAD/F-15/14; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SVZ; Product variable 2: 001; Product variable 4: 4; NationalCode: UC2.123102112
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 88.417; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 38.5; dpTot_SizingFlow_kPa [kPa]: 33.0; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
6 x BIB.021 | Havnivå |  |  | 28-25 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 28-25; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
32 x BIB.021 | Havnivå |  |  | 18-15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 18-15; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
24 x BIB.021 | Havnivå |  |  | 22-20 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 22-20; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 42.2; dpTot_SizingFlow_kPa [kPa]: 40.5; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 42.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 130; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 42.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 42.4; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2638.989; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 1.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 1.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2463.913; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 42.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 164.123; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 10 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 1.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM DN; MagiCAD Pset_Water - Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 5.25; Material Code: MM DN
4 x BIB.021 | Havnivå |  | Generic | 15-10 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - Description: MagiCAD - default reduction; ConnectionSize: 15-10; Insulation_thickness_mm [mm]: 30; National code: UB3
BIB.021 | Havnivå | KRA.004 | Generic | 12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 42.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6; Material Code: MM
12 x BIB.021 | Havnivå |  |  | 15-12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 15-12; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 42.4; dpTot_SizingFlow_kPa [kPa]: 41.1; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 1.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 470.263; Material Code: MM
