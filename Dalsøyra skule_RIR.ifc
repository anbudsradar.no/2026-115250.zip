Properties of the parts of a building model (IFC2X3), part 14 of 14

# IfcFlowSegment: Pressfittingssystem MM (1038)
Name | In | v_SizingFlow_ms [m/s] | pTot_SizingFlow_kPa [kPa] | dpTot_SizingFlow_kPa [kPa] | MagiCAD Pset_Heating, Insulation Material Code = MagiCAD Pset_Pipe, Insulation Material Code | ConnectionSize_DN | Insulation_thickness_mm [mm] | Length_mm | SystemType | SystemName | SystemClass | MagiCAD Pset_Water, Insulation Material Code | Material Code | Group
Pressfittingssystem MM | Havnivå | 0.1 | 5.2 | 0.0 | Cellegummi | 15 | 30 | 161 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 39.3 | 0.0 |  | 15 | 30 | 72 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.7 | 0.0 |  | 15 | 30 | 94 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 4.7 | 0.0 | Cellegummi | 22 | 30 | 333 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 39.3 | 0.0 | Cellegummi | 22 | 30 | 139 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 39.9 | 0.0 | Cellegummi | 22 | 30 | 259 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 3.9 | 0.0 | Cellegummi | 22 | 30 | 565 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 40.2 | 0.0 | Cellegummi | 22 | 30 | 133 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 3.7 | 0.0 | Cellegummi | 22 | 30 | 165 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 40.7 | 0.0 | Cellegummi | 18 | 30 | 271 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.2 | 0.0 | Cellegummi | 18 | 30 | 502 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 40.8 | 0.0 | Cellegummi | 18 | 30 | 209 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 3.0 | 0.1 | Cellegummi | 18 | 30 | 864 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 3.1 | 0.0 | Cellegummi | 22 | 30 | 447 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 40.7 | 0.0 | Cellegummi | 22 | 30 | 234 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 41.6 | 0.0 | Cellegummi | 22 | 30 | 510 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 2.1 | 0.1 | Cellegummi | 22 | 30 | 938 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 2.1 | 0.1 | Cellegummi | 22 | 30 | 1022 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 41.7 | 0.0 | Cellegummi | 22 | 30 | 547 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.2 | 0.0 | Cellegummi | 15 | 30 | 1363 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.2 | 0.0 | Cellegummi | 15 | 30 | 2507 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.5 | 0.0 | Cellegummi | 15 | 30 | 267 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 1.2 | 0.0 | Cellegummi | 15 | 30 | 526 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 42.4 | 0.0 | Cellegummi | 15 | 30 | 202 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 | Cellegummi | 15 | 30 | 468 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 41.0 | 0.0 | Cellegummi | 15 | 30 | 164 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.8 | 0.0 | Cellegummi | 15 | 30 | 173 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 2.7 | 0.0 | Cellegummi | 15 | 30 | 119 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 41.1 | 0.0 | Cellegummi | 15 | 30 | 144 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 | Cellegummi | 15 | 30 | 95 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 40.9 | 0.0 | Cellegummi | 15 | 30 | 178 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 40.9 | 0.0 | Cellegummi | 15 | 30 | 108 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 | Cellegummi | 15 | 30 | 413 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 40.5 | 0.0 | Cellegummi | 15 | 30 | 153 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.4 | 0.0 | Cellegummi | 15 | 30 | 573 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 3.8 | 0.0 | Cellegummi | 15 | 30 | 399 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 39.4 | 0.0 | Cellegummi | 28 | 30 | 293 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.4 | 0.0 | Cellegummi | 28 | 30 | 660 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 39.9 | 0.0 | Cellegummi | 18 | 30 | 100 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.0 | 0.0 | Cellegummi | 18 | 30 | 370 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 39.1 | 0.0 | Cellegummi | 22 | 30 | 214 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.7 | 0.1 | Cellegummi | 22 | 30 | 1125 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 38.5 | 0.0 | Cellegummi | 18 | 30 | 182 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.3 | 0.0 | Cellegummi | 18 | 30 | 192 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 38.1 | 0.0 | Cellegummi | 18 | 30 | 149 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.8 | 0.0 | Cellegummi | 18 | 30 | 442 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.9 | 0.0 | Cellegummi | 22 | 30 | 447 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 38.0 | 0.0 | Cellegummi | 22 | 30 | 170 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 | Cellegummi | 15 | 30 | 223 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.7 | 0.0 | Cellegummi | 15 | 30 | 123 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 5.2 | 0.0 | Cellegummi | 28 | 30 | 807 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 38.8 | 0.0 | Cellegummi | 28 | 30 | 148 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.3 | 0.0 | Cellegummi | 15 | 30 | 521 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 37.7 | 0.0 | Cellegummi | 15 | 30 | 165 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 37.8 | 0.0 | Cellegummi | 15 | 30 | 136 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 6.2 | 0.0 | Cellegummi | 15 | 30 | 250 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.5 | 0.0 | Cellegummi | 18 | 30 | 604 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 37.5 | 0.0 | Cellegummi | 18 | 30 | 182 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.7 | 0.1 | Cellegummi | 22 | 30 | 718 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 37.3 | 0.0 | Cellegummi | 22 | 30 | 246 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 36.4 | 0.0 | Cellegummi | 18 | 30 | 264 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.7 | 0.0 | Cellegummi | 18 | 30 | 808 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 36.5 | 0.0 | Cellegummi | 22 | 30 | 189 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.7 | 0.1 | Cellegummi | 22 | 30 | 671 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 36.6 | 0.0 | Cellegummi | 22 | 30 | 125 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.6 | 0.0 | Cellegummi | 22 | 30 | 161 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.7 | 0.0 | Cellegummi | 28 | 30 | 219 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 36.5 | 0.0 | Cellegummi | 28 | 30 | 100 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 | Cellegummi | 15 | 30 | 576 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.8 | 0.0 | Cellegummi | 28 | 30 | 396 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 38.1 | 0.0 | Cellegummi | 28 | 30 | 161 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 39.2 | 0.0 | Cellegummi | 18 | 30 | 120 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.8 | 0.0 | Cellegummi | 18 | 30 | 352 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 7.3 | 0.0 | Cellegummi | 15 | 30 | 105 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 7.2 | 0.0 | Cellegummi | 15 | 30 | 272 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 7.3 | 0.0 | Cellegummi | 18 | 30 | 328 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 36.8 | 0.0 | Cellegummi | 18 | 30 | 135 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 36.9 | 0.0 | Cellegummi | 15 | 30 | 86 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 7.2 | 0.0 | Cellegummi | 15 | 11 | 129 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.7 | 0.0 | Cellegummi | 18 | 30 | 488 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 36.4 | 0.0 | Cellegummi | 18 | 30 | 174 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.3 | 0.0 | Cellegummi | 15 | 30 | 435 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 35.9 | 0.0 | Cellegummi | 15 | 30 | 182 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 36.0 | 0.0 | Cellegummi | 15 | 30 | 60 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.2 | 0.0 | Cellegummi | 15 | 30 | 47 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 8.4 | 0.0 | Cellegummi | 15 | 30 | 188 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 35.9 | 0.0 | Cellegummi | 15 | 30 | 87 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.6 | 0.1 | Cellegummi | 18 | 30 | 585 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 35.7 | 0.0 | Cellegummi | 18 | 30 | 214 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.5 | 0.0 | Cellegummi | 15 | 30 | 451 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 35.8 | 0.0 | Cellegummi | 15 | 30 | 174 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 35.9 | 0.0 | Cellegummi | 15 | 30 | 40 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 35.9 | 0.0 | Cellegummi | 15 | 30 | 685 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.3 | 0.0 | Cellegummi | 15 | 30 | 93 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 8.3 | 0.0 | Cellegummi | 15 | 30 | 349 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 8.2 | 0.1 | Cellegummi | 18 | 30 | 1147 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 36.0 | 0.0 | Cellegummi | 18 | 30 | 792 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.4 | 0.0 | Cellegummi | 15 | 30 | 37 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.3 | 0.0 | Cellegummi | 15 | 30 | 55 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 35.9 | 0.0 | Cellegummi | 15 | 30 | 51 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 9.0 | 0.0 | Cellegummi | 22 | 30 | 309 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 35.3 | 0.0 | Cellegummi | 22 | 30 | 81 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.5 | 0.0 | Cellegummi | 15 | 30 | 614 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 8.7 | 0.0 | Cellegummi | 22 | 30 | 613 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 35.5 | 0.0 | Cellegummi | 22 | 30 | 180 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.0 | 0.1 | Cellegummi | 18 | 30 | 757 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 36.1 | 0.0 | Cellegummi | 18 | 30 | 160 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 36.5 | 0.0 | Cellegummi | 22 | 30 | 148 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.7 | 0.0 | Cellegummi | 22 | 30 | 401 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.3 | 0.0 | Cellegummi | 18 | 30 | 81 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.3 | 0.0 | Cellegummi | 18 | 30 | 260 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 5.6 | 0.0 | Cellegummi | 18 | 30 | 88 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 42.2 | 0.0 | Cellegummi | 15 | 30 | 130 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 42.4 | 0.1 | Cellegummi | 15 | 30 | 2639 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 1.3 | 0.1 | Cellegummi | 15 | 30 | 2464 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 42.3 | 0.0 | Cellegummi | 15 | 30 | 164 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 42.3 | 0.0 |  | 12 | 30 | 6 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 | Cellegummi | 15 | 30 | 470 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 42.4 | 0.0 | Cellegummi | 15 | 30 | 167 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.2 | 0.0 | Cellegummi | 15 | 30 | 792 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 |  | 12 | 30 | 6 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 40.9 | 0.0 |  | 12 | 30 | 16 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 40.1 | 0.0 | Cellegummi | 15 | 30 | 90 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 40.1 | 0.0 |  | 12 | 30 | 4 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.9 | 0.0 |  | 12 | 30 | 6 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 | Cellegummi | 15 | 30 | 224 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 38.2 | 0.0 | Cellegummi | 15 | 30 | 121 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.7 | 0.0 | Cellegummi | 15 | 30 | 512 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 38.1 | 0.0 | Cellegummi | 15 | 30 | 152 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.9 | 0.0 |  | 12 | 30 | 16 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 38.1 | 0.0 |  | 12 | 30 | 6 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.5 | 0.0 |  | 15 | 30 | 86 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.4 | 0.0 |  | 12 | 30 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 38.7 | 0.0 |  | 12 | 30 | 6 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 37.8 | 0.0 |  | 12 | 30 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 6.2 | 0.0 |  | 12 | 30 | 16 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 3.0 | 0.1 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 |  | 15 | 0 | 52 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 8 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 1073 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 185 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 8 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 935 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 185 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 1346 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 1046 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 1381 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 840 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 1726 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 1955 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 1540 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 860 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 1798 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 2073 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 94 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 69 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 38 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 208 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 178 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 122 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 442 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 649 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 191 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 147 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 170 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 31 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 70 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 48 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 29 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 54 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 51 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 77 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 181 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 149 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 46 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 30 | 47 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 0 | 55 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply |  |  | 320.003.04 Varme Tur 60° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 42 | 0 | 14 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.2 | 6.7 | 0.0 | Cellegummi | 22 | 30 | 73 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 37.9 | 0.0 | Cellegummi | 22 | 30 | 69 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.0 | 0.0 | Cellegummi | 22 | 30 | 257 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.5 | 38.8 | 0.1 | Cellegummi | 42 | 30 | 2085 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå |  |  |  | Cellegummi | 22 | 30 | 285 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  | Cellegummi | 22 | 30 | 862 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  | Cellegummi | 15 | 30 | 744 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  | Cellegummi | 15 | 30 | 288 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.1 | 35.7 | 0.0 | Cellegummi | 15 | 30 | 208 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.5 | 0.0 |  | 12 | 30 | 14 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 38.5 | 0.0 |  | 15 | 30 | 37 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 37.2 | 0.5 | Cellegummi | 22 | 30 | 1338 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå |  |  |  | Cellegummi | 22 | 30 | 3260 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  | Cellegummi | 22 | 12 | 3260 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  | Cellegummi | 22 | 12 | 1384 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Plan U1 | 0.2 | 7.2 | 0.0 | Cellegummi | 18 | 12 | 461 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Plan U1 | 0.2 | 7.1 | 0.0 | Cellegummi | 18 | 12 | 534 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Plan U1 | 0.2 | 37.2 | 0.2 | Cellegummi | 18 | 12 | 4182 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Plan U1 | 0.2 | 7.0 | 0.1 | Cellegummi | 18 | 12 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Plan U1 | 0.2 | 7.3 | 0.1 | Cellegummi | 18 | 12 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Plan U1 | 0.3 | 37.7 | 0.2 | Cellegummi | 28 | 13 | 3416 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Plan U1 | 0.3 | 6.2 | 0.2 | Cellegummi | 28 | 13 | 3416 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Plan U1 | 0.2 | 6.5 | 0.2 | Cellegummi | 18 | 12 | 3440 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Plan U1 | 0.2 | 37.5 | 0.2 | Cellegummi | 18 | 12 | 3367 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Plan U1 | 0.2 | 6.7 | 0.3 | Cellegummi | 18 | 12 | 4343 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Plan U1 | 0.2 | 37.5 | 0.1 | Cellegummi | 28 | 13 | 3064 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Plan U1 | 0.2 | 37.3 | 0.1 | Cellegummi | 28 | 13 | 4435 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Plan U1 | 0.2 | 6.5 | 0.1 | Cellegummi | 28 | 13 | 2928 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Plan U1 | 0.2 | 6.6 | 0.1 | Cellegummi | 28 | 13 | 4286 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Plan U1 | 0.2 | 6.8 | 0.0 | Cellegummi | 28 | 13 | 86 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Plan U1 | 0.2 | 6.8 | 0.0 | Cellegummi | 28 | 13 | 221 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Plan U1 |  |  |  |  | 15 | 0 | 410 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 24 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Plan U1 |  |  |  |  | 15 | 0 | 410 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 26 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Plan U1 | 0.2 | 6.9 | 0.1 | Cellegummi | 28 | 13 | 2422 |  | 320.004.04 Varme Tur 50° 2, 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Plan U1 | 0.2 | 6.7 | 0.1 | Cellegummi | 28 | 13 | 2162 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Plan U1 | 0.2 | 7.4 | 0.0 | Cellegummi | 18 | 12 | 323 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Plan U1 | 0.2 | 7.0 | 0.0 | Cellegummi | 28 | 13 | 287 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Plan U1 | 0.2 | 7.0 | 0.0 | Cellegummi | 18 | 12 | 500 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Plan U1 | 0.2 | 37.0 | 0.0 | Cellegummi | 18 | 12 | 117 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Plan U1 | 0.2 | 6.7 | 0.0 | Cellegummi | 28 | 13 | 482 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Plan U1 | 0.2 | 37.2 | 0.0 | Cellegummi | 28 | 13 | 103 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°

# IfcFlowStorageDevice: Aquapresso ADF 50.10
In: Plan U1
Type - Description: Expansion vessel for drinking water systems | full flow-through; PredefinedType: EXPANSION
MagiCAD Pset_PipeComponent - Description: Expansion vessel for drinking water systems | full flow-through; User Code: NTA001; Manufacturer: IMI; ConnectionSize_mm: 25; Product Code: Aquapresso ADF 50.10
Group: 311.001.01 KV Forbruksvann

# IfcFlowStorageDevice: SU 140.6
In: Havnivå
Type - Description: Expansion vessel; PredefinedType: EXPANSION
MagiCAD Pset_PipeComponent - Description: Expansion vessel; User Code: NTA.001; Manufacturer: IMI; ConnectionSize_mm: 20; Product Code: SU 140.6
Group: 320.003.05 Varme Retur 40°

# IfcFlowTerminal (2)
In: Havnivå
MagiCAD Pset_ConnectionNode - Comments: Viftekonvektor; Piping Pressure drop [kPa]: 10.0; Piping Volume [L]: 10.0
Group: 320.003.05 Varme Retur 40°; 320.004.04 Varme Tur 50°
Name | Piping Flow [L/s] | Piping Power [W] | Piping Total pressure [kPa]
MC_ConnectionNode_Hydronic | 0.06727 | 2800 | 14.8
MC_ConnectionNode_Hydronic | 0.05766 | 2400 | 13.1

# IfcFlowTerminal: PRE S 11-608_15 (14)
In: Havnivå
Type - Description: PRE Series; PredefinedType: CONVECTOR
MagiCAD Pset_Radiator - Description: PRE Series; Product variable 1: LHA; Product variable 2: 012; Product variable 4: 5; User Code: LHA.01; NationalCode: YL1.12111; Manufacturer: Epecon Lyngson; Length_mm: 800; Height_mm: 600; Product Code: PRE S 11-608; Object Variable 1: 11-600-800
Group: 320.003.05 Varme Retur 40°; 320.004.04 Varme Tur 50°
Name | pTot_SizingFlow_kPa [kPa]
2 x PRE S 11-608_15 | 8.5
PRE S 11-608_15 | 8.4
PRE S 11-608_15 | 5.5
2 x PRE S 11-608_15 | 5.8
PRE S 11-608_15 | 5.7
PRE S 11-608_15 | 6.2
2 x PRE S 11-608_15 | 1.3
3 x PRE S 11-608_15 | 1.6
PRE S 11-608_15 | 2.9

# IfcFlowTerminal: PRE S 22-510_15-1 (22)
In: Havnivå
Type - Description: PRE Series; PredefinedType: CONVECTOR
MagiCAD Pset_Radiator - Description: PRE Series; Product variable 1: LHA; Product variable 2: 013; Product variable 4: 5; User Code: LHA.02; NationalCode: YL1.12111; Manufacturer: Epecon Lyngson; Length_mm: 1000; Height_mm: 500; Product Code: PRE S 22-510; Object Variable 1: 22-500-1000
Group: 320.003.05 Varme Retur 40°; 320.004.04 Varme Tur 50°
Name | pTot_SizingFlow_kPa [kPa]
PRE S 22-510_15-1 | 8.3
PRE S 22-510_15-1 | 8.6
PRE S 22-510_15-1 | 8.2
2 x PRE S 22-510_15-1 | 7.2
9 x PRE S 22-510_15-1
PRE S 22-510_15-1 | 7.0
PRE S 22-510_15-1 | 6.9
PRE S 22-510_15-1 | 6.4
PRE S 22-510_15-1 | 5.3
PRE S 22-510_15-1 | 1.4
PRE S 22-510_15-1 | 2.9
PRE S 22-510_15-1 | 2.8
PRE S 22-510_15-1 | 3.8

# IfcFlowTerminal: PRE S 22-518_15-1 (10)
In: Havnivå
Type - Description: PRE Series; PredefinedType: CONVECTOR
MagiCAD Pset_Radiator - Description: PRE Series; Product variable 1: LHA; Product variable 2: 013; Product variable 4: 5; User Code: LHA.03; NationalCode: YL1.12111; Manufacturer: Epecon Lyngson; Length_mm: 1800; Height_mm: 500; Product Code: PRE S 22-518; Object Variable 1: 22-500-1800
Group: 320.003.05 Varme Retur 40°; 320.004.04 Varme Tur 50°
Name
PRE S 22-518_15-1 | MagiCAD Pset_Radiator - pTot_SizingFlow_kPa [kPa]: 8.3
5 x PRE S 22-518_15-1
PRE S 22-518_15-1 | MagiCAD Pset_Radiator - pTot_SizingFlow_kPa [kPa]: 6.4
PRE S 22-518_15-1 | MagiCAD Pset_Radiator - pTot_SizingFlow_kPa [kPa]: 5.0
PRE S 22-518_15-1 | MagiCAD Pset_Radiator - pTot_SizingFlow_kPa [kPa]: 6.1
PRE S 22-518_15-1 | MagiCAD Pset_Radiator - pTot_SizingFlow_kPa [kPa]: 3.0

# IfcFlowTerminal: PRE S 22-520_15-1 (23)
In: Havnivå
Type - Description: PRE Series; PredefinedType: CONVECTOR
MagiCAD Pset_Radiator - Description: PRE Series; Product variable 1: LHA; Product variable 2: 013; Product variable 4: 5; User Code: LHA.04; NationalCode: YL1.12111; Manufacturer: Epecon Lyngson; Length_mm: 2000; Height_mm: 500; Product Code: PRE S 22-520; Object Variable 1: 22-500-2000
Group: 320.003.05 Varme Retur 40°; 320.004.04 Varme Tur 50°
Name | pTot_SizingFlow_kPa [kPa]
PRE S 22-520_15-1 | 8.5
PRE S 22-520_15-1 | 8.7
PRE S 22-520_15-1 | 8.0
10 x PRE S 22-520_15-1
PRE S 22-520_15-1 | 6.9
PRE S 22-520_15-1 | 5.6
PRE S 22-520_15-1 | 6.7
PRE S 22-520_15-1 | 4.3
PRE S 22-520_15-1 | 6.6
PRE S 22-520_15-1 | 3.5
2 x PRE S 22-520_15-1 | 2.5
PRE S 22-520_15-1 | 1.5
PRE S 22-520_15-1 | 3.7

# IfcFlowTerminal: PRE S 22-523_15-1 (6)
In: Havnivå
Type - Description: PRE Series; PredefinedType: CONVECTOR
MagiCAD Pset_Radiator - Description: PRE Series; Product variable 1: LHA; Product variable 2: 013; Product variable 4: 5; User Code: LHA.05; NationalCode: YL1.12111; Manufacturer: Epecon Lyngson; Length_mm: 2300; Height_mm: 500; Product Code: PRE S 22-523; Object Variable 1: 22-500-2300
Group: 320.003.05 Varme Retur 40°; 320.004.04 Varme Tur 50°
Name | pTot_SizingFlow_kPa [kPa]
PRE S 22-523_15-1 | 7.4
PRE S 22-523_15-1 | 6.4
PRE S 22-523_15-1 | 4.9
PRE S 22-523_15-1 | 5.0
PRE S 22-523_15-1 | 4.1
PRE S 22-523_15-1 | 5.5

# IfcFlowTerminal: PRE S 33-520_15-1 (9)
In: Havnivå
Type - Description: PRE Series; PredefinedType: CONVECTOR
MagiCAD Pset_Radiator - Description: PRE Series; Product variable 1: LHA; Product variable 2: 011; Product variable 4: 5; User Code: LHA.06; NationalCode: YL1.12111; Manufacturer: Epecon Lyngson; Length_mm: 2000; Height_mm: 500; Product Code: PRE S 33-520; Object Variable 1: 33-500-2000
Group: 320.003.05 Varme Retur 40°; 320.004.04 Varme Tur 50°
Name | pTot_SizingFlow_kPa [kPa]
PRE S 33-520_15-1 | 9.0
4 x PRE S 33-520_15-1
PRE S 33-520_15-1 | 6.4
PRE S 33-520_15-1 | 4.0
PRE S 33-520_15-1 | 3.3
PRE S 33-520_15-1 | 6.6

# IfcFlowTerminal: PRE S 33-523_15 (22)
Type - Description: PRE Series; PredefinedType: CONVECTOR
MagiCAD Pset_Radiator - Description: PRE Series; Product variable 1: LHA; Product variable 2: 011; Product variable 4: 5; User Code: LHA.07; NationalCode: YL1.12111; Manufacturer: Epecon Lyngson; Length_mm: 2300; Height_mm: 500; Product Code: PRE S 33-523; Object Variable 1: 33-500-2300
Group: 320.003.05 Varme Retur 40°; 320.004.04 Varme Tur 50°
Name | In | pTot_SizingFlow_kPa [kPa]
10 x PRE S 33-523_15 | Havnivå
PRE S 33-523_15 | Havnivå | 7.7
2 x PRE S 33-523_15 | Havnivå | 7.9
PRE S 33-523_15 | Havnivå | 9.5
PRE S 33-523_15 | Havnivå | 6.2
PRE S 33-523_15 | Havnivå | 4.9
PRE S 33-523_15 | Havnivå | 8.4
PRE S 33-523_15 | Havnivå | 8.1
PRE S 33-523_15 | Havnivå | 8.2
PRE S 33-523_15 | Havnivå | 7.1
PRE S 33-523_15 | Havnivå | 6.3
PRE S 33-523_15 | Plan U1 | 7.2

# IfcFlowTerminal: PRE S 33-530_15-1 (6)
Type - Description: PRE Series; PredefinedType: CONVECTOR
MagiCAD Pset_Radiator - Description: PRE Series; Product variable 1: LHA; Product variable 2: 011; Product variable 4: 5; User Code: LHA.08; NationalCode: YL1.12111; Manufacturer: Epecon Lyngson; Length_mm: 3000; Height_mm: 500; Product Code: PRE S 33-530; Object Variable 1: 33-500-3000
Group: 320.003.05 Varme Retur 40°; 320.004.04 Varme Tur 50°
Name | In | pTot_SizingFlow_kPa [kPa]
PRE S 33-530_15-1 | Havnivå | 8.9
PRE S 33-530_15-1 | Havnivå
PRE S 33-530_15-1 | Havnivå | 10.0
PRE S 33-530_15-1 | Havnivå | 9.3
PRE S 33-530_15-1 | Plan U1
PRE S 33-530_15-1 | Plan U1 | 6.8

# IfcFlowTerminal: Sluk 75 rustfri
In: Havnivå
Type - Description: Sluk 75 rustfri; PredefinedType: FLOORWASTE
MagiCAD Pset_DrainageDevices - Description: Sluk 75 rustfri; Product variable 1: KNA; Product variable 2: 003; Product variable 4: 5; User Code: KNA.003; NationalCode: UF5.112221; Product Code: Sluk 75 rustfri
Group: 314.001.01 Spillvann

# IfcFlowTreatmentDevice: Y222 DN40-149B1772 (2)
In: Havnivå
Type - Description: Filter; PredefinedType: STRAINER
MagiCAD Pset_PipeComponent - Description: Filter; Product variable 1: MVA; Product variable 2: 001; Product variable 4: 4; User Code: MVA.001; NationalCode: UD2.2319-; Manufacturer: Danfoss; ConnectionSize_mm: 40; Product Code: Y222 DN40-149B1772
Group: 320.003.05 Varme Retur 40°

# IfcSystem (8)
Name | Description
320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40°
320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50°
320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60°
320.002.05 Varme Retur 50° | 320.002.05 Varme Retur 50°
312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann
311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann
312.002.01 VVC | 312.002.01 VVC
314.001.01 Spillvann | 314.001.01 Spillvann
