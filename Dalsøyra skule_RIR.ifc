Properties of the parts of a building model (IFC2X3), part 13 of 14

# IfcFlowSegment: Pressfittingssystem MM (1038)
Name | In | v_SizingFlow_ms [m/s] | pTot_SizingFlow_kPa [kPa] | dpTot_SizingFlow_kPa [kPa] | MagiCAD Pset_Heating, Insulation Material Code = MagiCAD Pset_Pipe, Insulation Material Code | ConnectionSize_DN | Insulation_thickness_mm [mm] | Length_mm | SystemType | SystemName | SystemClass | MagiCAD Pset_Water, Insulation Material Code | Material Code | Group
Pressfittingssystem MM | Havnivå | 0.2 | 6.2 | 0.0 | Cellegummi | 15 | 30 | 508 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.5 | 6.2 | 0.0 | Cellegummi | 42 | 30 | 9 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 6.4 | 0.0 | Cellegummi | 15 | 30 | 1054 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 37.7 | 0.0 | Cellegummi | 15 | 30 | 1154 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 6.4 | 0.0 |  | 15 | 0 | 328 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 6.5 | 0.1 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 6.4 | 0.0 |  | 15 | 0 | 418 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 6.4 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 6.3 | 0.0 | Cellegummi | 42 | 30 | 639 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 37.8 | 0.0 | Cellegummi | 42 | 30 | 449 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 6.2 | 0.0 |  | 15 | 0 | 119 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 6.2 | 0.0 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 6.2 | 0.0 |  | 15 | 0 | 169 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 6.2 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 6.2 | 0.0 |  | 15 | 30 | 63 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 6.2 | 0.0 | Cellegummi | 15 | 30 | 441 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 6.2 | 0.0 | Cellegummi | 42 | 30 | 96 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 37.8 | 0.0 | Cellegummi | 15 | 30 | 166 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 37.9 | 0.0 | Cellegummi | 42 | 30 | 101 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 |  | 15 | 0 | 119 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 |  | 15 | 0 | 214 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 | Cellegummi | 15 | 30 | 262 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.5 | 0.0 |  | 28 | 0 | 143 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.0 | 0.0 |  | 28 | 0 | 226 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.6 | 0.1 |  | 28 | 0 | 2362 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.9 | 0.1 |  | 28 | 0 | 2222 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.9 | 0.0 | Cellegummi | 28 | 30 | 324 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 90 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 38 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 90 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 38 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 85 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 39 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 88 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 40 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.5 | 38.6 | 0.6 | Cellegummi | 42 | 30 | 10174 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 | Cellegummi | 15 | 30 | 362 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.5 | 5.4 | 0.7 | Cellegummi | 42 | 30 | 10174 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.8 | 0.0 | Cellegummi | 28 | 30 | 483 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.4 | 0.3 | Cellegummi | 28 | 30 | 7128 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.6 | 0.0 | Cellegummi | 28 | 30 | 424 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 38.1 | 0.0 | Cellegummi | 28 | 30 | 503 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 38.5 | 0.3 | Cellegummi | 28 | 30 | 7143 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 | Cellegummi | 15 | 30 | 1335 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 38.1 | 0.0 | Cellegummi | 15 | 30 | 1394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.3 | 0.0 |  | 15 | 0 | 108 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.3 | 0.1 |  | 15 | 0 | 2396 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.3 | 0.0 |  | 15 | 0 | 188 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 5.2 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 5.2 | 0.0 | Cellegummi | 15 | 30 | 208 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 5.3 | 0.0 | Cellegummi | 15 | 30 | 308 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 38.7 | 0.0 | Cellegummi | 15 | 30 | 139 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.2 | 0.0 | Cellegummi | 15 | 30 | 245 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.5 | 5.1 | 0.1 | Cellegummi | 42 | 30 | 2149 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 3.6 | 0.0 | Cellegummi | 22 | 12 | 131 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 3.8 | 0.2 | Cellegummi | 22 | 12 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 3.4 | 0.0 | Cellegummi | 22 | 12 | 131 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 3.2 | 0.2 | Cellegummi | 22 | 12 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 310 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 41 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 320 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 43 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 3.8 | 0.0 | Cellegummi | 22 | 30 | 199 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 3.2 | 0.0 | Cellegummi | 22 | 30 | 99 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 3.6 | 0.0 | Cellegummi | 22 | 12 | 151 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 3.4 | 0.0 | Cellegummi | 22 | 12 | 211 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 1.8 | 0.4 | Cellegummi | 22 | 30 | 5098 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 42.0 | 0.4 | Cellegummi | 22 | 30 | 5191 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 2.6 | 0.0 |  | 22 | 0 | 284 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
2 x Pressfittingssystem MM | Havnivå | 0.3 | 2.8 | 0.2 |  | 22 | 0 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 2.4 | 0.0 |  | 22 | 0 | 284 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
2 x Pressfittingssystem MM | Havnivå | 0.3 | 2.2 | 0.2 |  | 22 | 0 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 2.8 | 0.0 | Cellegummi | 22 | 30 | 194 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 2.2 | 0.0 | Cellegummi | 22 | 30 | 94 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
2 x Pressfittingssystem MM | Havnivå | 0.3 | 2.6 | 0.0 |  | 22 | 0 | 151 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
2 x Pressfittingssystem MM | Havnivå | 0.3 | 2.4 | 0.0 |  | 22 | 0 | 211 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 1.7 | 0.4 | Cellegummi | 22 | 30 | 5014 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 2.6 | 0.0 |  | 22 | 0 | 191 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 2.4 | 0.0 |  | 22 | 0 | 191 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 475 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 45 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 475 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 45 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 475 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 48 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 475 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 48 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 2.8 | 0.0 | Cellegummi | 22 | 30 | 199 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 2.2 | 0.0 | Cellegummi | 22 | 30 | 99 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 |  | 15 | 0 | 46 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
2 x Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
2 x Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 |  | 15 | 0 | 96 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.2 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 |  | 15 | 30 | 40 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.2 | 0.0 |  | 15 | 30 | 322 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 |  | 15 | 0 | 16 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 |  | 15 | 30 | 425 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 42.5 | 0.1 | Cellegummi | 15 | 30 | 2544 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.1 | 0.1 | Cellegummi | 15 | 30 | 2404 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 42.4 | 0.1 | Cellegummi | 15 | 30 | 2260 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 | Cellegummi | 15 | 30 | 2070 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 42.6 | 0.0 | Cellegummi | 22 | 30 | 551 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
2 x Pressfittingssystem MM | Havnivå | 0.1 | 1.6 | 0.0 |  | 15 | 0 | 44 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
3 x Pressfittingssystem MM | Havnivå | 0.1 | 1.6 | 0.0 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
2 x Pressfittingssystem MM | Havnivå | 0.1 | 1.6 | 0.0 |  | 15 | 0 | 94 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
2 x Pressfittingssystem MM | Havnivå | 0.1 | 1.5 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.6 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.6 | 0.0 |  | 15 | 0 | 119 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.5 | 0.0 |  | 15 | 0 | 224 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.6 | 0.0 |  | 15 | 30 | 209 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.6 | 0.0 | Cellegummi | 15 | 30 | 1000 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.6 | 0.0 |  | 15 | 30 | 185 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.6 | 0.0 | Cellegummi | 15 | 30 | 999 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.6 | 0.0 | Cellegummi | 15 | 30 | 583 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 42.5 | 0.1 | Cellegummi | 18 | 30 | 2474 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.7 | 0.1 | Cellegummi | 15 | 30 | 1943 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 1.7 | 0.0 | Cellegummi | 15 | 30 | 335 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.5 | 0.0 |  | 15 | 30 | 92 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.5 | 0.0 | Cellegummi | 15 | 30 | 849 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.5 | 0.0 | Cellegummi | 15 | 30 | 403 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 1.2 | 0.1 | Cellegummi | 18 | 30 | 2654 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 1.4 | 0.0 | Cellegummi | 15 | 30 | 685 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.5 | 0.0 |  | 15 | 30 | 122 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.5 | 0.0 | Cellegummi | 15 | 30 | 850 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.5 | 0.1 | Cellegummi | 15 | 30 | 1924 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.4 | 0.0 |  | 15 | 0 | 148 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.5 | 0.1 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.4 | 0.0 |  | 15 | 0 | 238 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.4 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 | Cellegummi | 15 | 30 | 1166 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 42.3 | 0.0 | Cellegummi | 15 | 30 | 1309 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 1.7 | 0.2 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 1.5 | 0.0 |  | 15 | 0 | 117 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 1.3 | 0.2 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 1.5 | 0.0 |  | 15 | 0 | 197 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 42.5 | 0.1 | Cellegummi | 15 | 30 | 1320 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 1.2 | 0.1 | Cellegummi | 15 | 30 | 1194 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 1.1 | 0.0 | Cellegummi | 22 | 30 | 374 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 42.5 | 0.0 | Cellegummi | 22 | 30 | 554 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 1.1 | 0.0 | Cellegummi | 22 | 30 | 451 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 41.0 | 0.0 | Cellegummi | 15 | 30 | 243 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.8 | 0.0 | Cellegummi | 15 | 30 | 346 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.1 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.8 | 0.0 |  | 15 | 0 | 448 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.8 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 2.8 | 0.0 |  | 15 | 0 | 498 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 3.1 | 0.0 |  | 15 | 30 | 26 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 2.6 | 0.2 | Cellegummi | 18 | 30 | 3387 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 3.1 | 0.1 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.0 | 0.0 |  | 15 | 0 | 212 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 2.8 | 0.1 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 2.9 | 0.0 |  | 15 | 0 | 262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 2.7 | 0.0 | Cellegummi | 15 | 30 | 183 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 2.8 | 0.0 | Cellegummi | 15 | 30 | 362 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 41.0 | 0.0 | Cellegummi | 15 | 30 | 383 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 41.2 | 0.2 | Cellegummi | 18 | 30 | 3147 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 |  | 15 | 30 | 26 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.9 | 0.0 |  | 15 | 30 | 26 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.9 | 0.2 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.7 | 0.0 |  | 15 | 0 | 192 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.5 | 0.2 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 3.7 | 0.0 |  | 15 | 0 | 242 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 |  | 15 | 0 | 131 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 |  | 15 | 0 | 181 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
2 x Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 | Cellegummi | 15 | 30 | 202 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 40.9 | 0.0 | Cellegummi | 15 | 30 | 135 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 40.9 | 0.0 | Cellegummi | 15 | 30 | 191 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 3.0 | 0.0 |  | 15 | 30 | 26 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 |  | 15 | 0 | 102 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 40.9 | 0.0 | Cellegummi | 15 | 30 | 643 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 41.0 | 0.0 | Cellegummi | 15 | 30 | 1072 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 41.0 | 0.0 | Cellegummi | 15 | 30 | 990 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 | Cellegummi | 15 | 30 | 559 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 | Cellegummi | 15 | 30 | 1072 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 | Cellegummi | 15 | 30 | 124 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 2.8 | 0.1 | Cellegummi | 15 | 30 | 1030 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 3.8 | 0.0 | Cellegummi | 15 | 11 | 129 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 3.9 | 0.1 | Cellegummi | 15 | 11 | 2395 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 3.8 | 0.0 | Cellegummi | 15 | 11 | 179 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 3.8 | 0.0 | Cellegummi | 15 | 11 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 3.8 | 0.0 | Cellegummi | 15 | 30 | 675 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 3.7 | 0.0 | Cellegummi | 15 | 30 | 1638 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 40.1 | 0.0 | Cellegummi | 15 | 30 | 783 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 40.2 | 0.0 | Cellegummi | 15 | 30 | 1538 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 42.0 | 0.4 | Cellegummi | 22 | 30 | 5154 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 14.8 | 0.0 |  | 22 | 30 | 64 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.8 | 0.0 |  | 22 | 30 | 229 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 4.1 | 0.0 | Cellegummi | 18 | 12 | 318 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 4.1 | 0.0 | Cellegummi | 18 | 12 | 211 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 37.7 | 0.0 | Cellegummi | 28 | 30 | 320 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 37.9 | 0.0 | Cellegummi | 35 | 30 | 270 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.2 | 0.0 | Cellegummi | 28 | 30 | 220 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.5 | 5.5 | 0.6 | Cellegummi | 35 | 30 | 6915 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 13.1 | 0.0 | Cellegummi | 18 | 30 | 71 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 40.9 | 0.1 | Cellegummi | 18 | 30 | 860 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 3.1 | 0.0 | Cellegummi | 18 | 30 | 236 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 2.9 | 0.1 | Cellegummi | 18 | 30 | 1046 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 40.9 | 0.0 | Cellegummi | 18 | 30 | 220 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 40.9 | 0.0 | Cellegummi | 18 | 30 | 242 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 301 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 41 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 311 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 43 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 291 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 46 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 296 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 46 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 311 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 44 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 316 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 44 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 4.3 | 0.0 |  | 22 | 0 | 135 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.2 | 0.0 |  | 22 | 0 | 185 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 250 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 17 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 250 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 18 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 320 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 20 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 320 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 22 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 868 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 10 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.1 | 8.4 | 0.0 | Cellegummi | 15 | 11 | 138 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.2 | 0.0 |  | 15 | 0 | 28 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.3 | 0.1 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.5 | 7.3 | 0.0 | Cellegummi | 35 | 30 | 80 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.5 | 36.9 | 0.0 | Cellegummi | 35 | 30 | 275 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 6.4 | 0.0 | Cellegummi | 42 | 30 | 53 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 14.8 | 0.0 |  | 22 | 30 | 365 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.8 | 0.0 |  | 22 | 30 | 57 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 37.9 | 0.0 | Cellegummi | 18 | 30 | 121 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.6 | 4.5 | 0.2 | Cellegummi | 54 | 30 | 2706 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.5 | 0.0 | Cellegummi | 18 | 30 | 61 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.8 | 0.0 |  | 22 | 0 | 66 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.6 | 0.0 |  | 22 | 0 | 66 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 7.4 | 0.0 |  | 18 | 0 | 229 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 35.9 | 0.1 | Cellegummi | 22 | 30 | 1157 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 9.9 | 0.0 | Cellegummi | 22 | 30 | 202 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.9 | 0.0 | Cellegummi | 15 | 30 | 203 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 9.2 | 0.0 | Cellegummi | 18 | 30 | 263 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.5 | 0.0 | Cellegummi | 15 | 30 | 297 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 36.0 | 0.0 | Cellegummi | 15 | 30 | 120 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.7 | 0.0 | Cellegummi | 15 | 30 | 259 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.2 | 0.0 | Cellegummi | 18 | 30 | 242 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.1 | 0.0 | Cellegummi | 22 | 30 | 523 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.3 | 0.0 | Cellegummi | 22 | 30 | 194 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.6 | 0.0 | Cellegummi | 18 | 30 | 518 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 9.2 | 0.0 | Cellegummi | 22 | 30 | 347 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.7 | 0.0 | Cellegummi | 15 | 30 | 343 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.5 | 0.0 | Cellegummi | 18 | 30 | 145 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 37.9 | 0.0 | Cellegummi | 18 | 30 | 39 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.4 | 0.0 | Cellegummi | 18 | 30 | 199 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.2 | 0.0 | Cellegummi | 22 | 30 | 71 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.3 | 0.0 | Cellegummi | 15 | 30 | 61 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.0 | 0.0 | Cellegummi | 18 | 30 | 168 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.4 | 0.0 |  | 15 | 30 | 66 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.3 | 0.0 | Cellegummi | 22 | 30 | 186 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.6 | 0.0 | Cellegummi | 22 | 30 | 346 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.2 | 0.0 | Cellegummi | 22 | 30 | 105 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.5 | 0.0 | Cellegummi | 18 | 30 | 189 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 13.2 | 0.0 | Cellegummi | 18 | 30 | 425 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 3.8 | 0.0 | Cellegummi | 22 | 30 | 212 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 2.9 | 0.0 | Cellegummi | 22 | 30 | 456 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 2.8 | 0.0 | Cellegummi | 22 | 30 | 456 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 | Cellegummi | 15 | 30 | 1503 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.3 | 0.0 | Cellegummi | 15 | 30 | 2607 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.6 | 0.0 | Cellegummi | 15 | 30 | 167 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 1.7 | 0.0 | Cellegummi | 15 | 30 | 264 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 1.5 | 0.0 | Cellegummi | 15 | 30 | 217 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.2 | 0.0 | Cellegummi | 15 | 30 | 111 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 | Cellegummi | 15 | 30 | 100 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 3.0 | 0.0 | Cellegummi | 15 | 30 | 209 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 2.9 | 0.0 | Cellegummi | 15 | 30 | 74 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.9 | 0.0 | Cellegummi | 15 | 30 | 292 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.2 | 0.0 | Cellegummi | 28 | 30 | 170 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 3.9 | 0.0 | Cellegummi | 15 | 30 | 220 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.5 | 0.0 | Cellegummi | 22 | 30 | 236 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.3 | 0.0 | Cellegummi | 18 | 30 | 169 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 10.4 | 0.0 | Cellegummi | 28 | 30 | 496 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.8 | 0.0 | Cellegummi | 15 | 30 | 314 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 6.2 | 0.0 | Cellegummi | 15 | 30 | 177 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.8 | 0.0 | Cellegummi | 18 | 30 | 300 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 6.5 | 0.0 | Cellegummi | 15 | 30 | 381 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.5 | 0.0 | Cellegummi | 22 | 30 | 447 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.1 | 0.0 | Cellegummi | 18 | 30 | 426 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.6 | 0.0 | Cellegummi | 22 | 30 | 302 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 36.6 | 0.0 | Cellegummi | 22 | 30 | 92 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 9.0 | 0.0 | Cellegummi | 28 | 30 | 254 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 | Cellegummi | 15 | 30 | 251 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.7 | 0.0 | Cellegummi | 28 | 30 | 310 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 14.9 | 0.0 | Cellegummi | 22 | 30 | 664 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.2 | 0.0 | Cellegummi | 18 | 30 | 166 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.9 | 0.0 |  | 15 | 30 | 17 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.2 | 0.0 |  | 18 | 30 | 97 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.5 | 0.0 | Cellegummi | 18 | 30 | 177 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 37.5 | 0.0 |  | 18 | 30 | 38 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.5 | 0.0 |  | 15 | 30 | 116 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 37.5 | 0.0 |  | 15 | 30 | 27 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.8 | 0.0 | Cellegummi | 22 | 30 | 216 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.7 | 0.0 | Cellegummi | 15 | 30 | 90 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.6 | 0.0 | Cellegummi | 15 | 30 | 517 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 37.4 | 0.0 | Cellegummi | 15 | 30 | 73 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 37.4 | 0.1 | Cellegummi | 15 | 30 | 697 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 37.4 | 0.0 | Cellegummi | 18 | 30 | 800 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.6 | 0.0 | Cellegummi | 18 | 30 | 750 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.9 | 0.0 |  | 15 | 0 | 357 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.9 | 0.0 |  | 15 | 0 | 437 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 7.1 | 0.0 | Cellegummi | 15 | 30 | 39 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 37.2 | 0.0 | Cellegummi | 22 | 30 | 127 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 37.4 | 0.0 | Cellegummi | 15 | 30 | 41 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 37.1 | 0.0 | Cellegummi | 18 | 30 | 228 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.0 | 0.0 | Cellegummi | 18 | 30 | 488 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.0 | 0.0 | Cellegummi | 18 | 30 | 79 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.6 | 0.0 | Cellegummi | 15 | 30 | 290 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.8 | 0.0 | Cellegummi | 15 | 30 | 35 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.5 | 0.0 |  | 15 | 30 | 93 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 38.5 | 0.0 | Cellegummi | 15 | 30 | 55 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.3 | 0.0 | Cellegummi | 15 | 30 | 52 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 38.7 | 0.0 | Cellegummi | 15 | 30 | 98 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
