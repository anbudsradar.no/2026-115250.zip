Properties of the parts of a building model (IFC2X3), part 1 of 14

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Dalsøyra skule_RIR.ifc
Time: 2026-08-28T15:02:21
Author: - -
Organization: -
Written by: BSProLib Rel.2025.9.0.14
Made in: MagiCAD For Revit 2026 UR-1
Authorization: -

# IfcSite
RefLatitude: 59, 54, 44, 239196; RefLongitude: 10, 45, 0, 0; RefElevation: 0 mm
MagiCAD Pset_Site - Reference elevation: 0; Reference latitude: 59, 54, 44, 239196; Reference longitude: 10, 45, 0, 0

# IfcBuildingStorey (2)
In: mc-building
Name | LongName = Name | Elevation (mm)
Havnivå | Havnivå | 0
Plan U1 | Plan U1 | -3500

# IfcBuildingElementProxy (7)
In: Havnivå
Name
Ventilasjonsaggregat Gold F RX025
2 x Standard
2 x Luft-vann varmepumpe 30 kW | Group: 320.003.05 Varme Retur 40°; 320.003.04 Varme Tur 60°
Luft-vann varmepumpe 30 kW
El 160 Eco Parca 156 kW | Group: 320.003.04 Varme Tur 60°

# IfcCovering: BIB.021 (1891)
Type - Description: Kondensisolasjon Økende 13mm
PredefinedType: INSULATION
MagiCAD Pset_Pipe - NationalCode: SB2.12119815; Description: Kondensisolasjon Økende 13mm
Name | In | MagiCAD Pset_Pipe, User Code | MagiCAD Pset_Pipe, Manufacturer | ConnectionSize_DN | Insulation_thickness_mm | SystemType | SystemName | SystemClass | MagiCAD Pset_Pipe, Insulation Material Code
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 7.3; dpTot_SizingFlow_kPa [kPa]: 0.5; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6385.985; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 477.637; Material Code: MM
BIB.021 | Havnivå |  |  | 54-54-42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 54-54-42; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 54 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 4.8; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3737.983; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 4.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1195.676; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 42.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 162.255; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 39.9; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1137.676; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 38.9; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2429.059; Material Code: MM
BIB.021 | Havnivå |  |  | 54-54-42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 54-54-42; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 54 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 39.4; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3787.983; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 42.7; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 5728.947; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 40.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 107.182; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 1.2; dpTot_SizingFlow_kPa [kPa]: 0.5; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 6028.947; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 36.9; dpTot_SizingFlow_kPa [kPa]: 0.5; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6590.985; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 4.5; dpTot_SizingFlow_kPa [kPa]: 0.9; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 9404.946; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 39.5; dpTot_SizingFlow_kPa [kPa]: 0.9; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 9324.946; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.8; dpTot_SizingFlow_kPa [kPa]: 0.5; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 4393.353; Material Code: MM
2 x BIB.021 | Havnivå |  |  | 42-42-22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 42-42-22; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 50 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 5.1; dpTot_SizingFlow_kPa [kPa]: 1.8; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 22973.172; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.2; dpTot_SizingFlow_kPa [kPa]: 0.5; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 4284.305; Material Code: MM
2 x BIB.021 | Havnivå |  |  | 42-42-22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 42-42-22; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 50 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 39.1; dpTot_SizingFlow_kPa [kPa]: 1.7; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 22973.172; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 4.1; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6677.024; Material Code: MM
4 x BIB.021 | Havnivå |  |  | 42-42-28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 42-42-28; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 4.1; dpTot_SizingFlow_kPa [kPa]: 0.5; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6516.02; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 39.7; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6814.231; Material Code: MM
4 x BIB.021 | Havnivå |  |  | 42-42-28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 42-42-28; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 39.8; dpTot_SizingFlow_kPa [kPa]: 0.5; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6514.02; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.3; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6440.63; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 36.8; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6260.63; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 35.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 87.413; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 4.125; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.4; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 4104.098; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.7; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3982.836; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.5; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1757.996; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.6; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2503.129; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 35.8; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2157.996; Material Code: MM
BIB.021 | Havnivå |  |  | 35-35-35 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 35-35-35; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
2 x BIB.021 | Havnivå |  |  | 35-35-35 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 35-35-35; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 36.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3354.492; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.1; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3174.641; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 279.95; Material Code: MM
5 x BIB.021 | Havnivå |  |  | 28-28-22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 28-28-22; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6686.875; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.4; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3479.418; Material Code: MM
5 x BIB.021 | Havnivå |  |  | 28-28-22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 28-28-22; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.8; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6499.375; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 38.4; dpTot_SizingFlow_kPa [kPa]: 0.6; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6969.453; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 134.415; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 5.5; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1501.216; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.0; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6012.606; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 39.0; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6104.568; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 123.3; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2070.325; Material Code: MM
2 x BIB.021 | Havnivå |  | Generic | 35-35 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 35-35; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 213.379; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1045.75; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.8; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1685.123; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.7; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2956.081; Material Code: MM
17 x BIB.021 | Havnivå |  | Generic | 22-22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 22-22; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1007.625; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1610.469; Material Code: MM
10 x BIB.021 | Havnivå |  | Generic | 28-28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 28-28; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.5; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3021.786; Material Code: MM
16 x BIB.021 | Havnivå |  | Generic | 22-22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 22-22; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 40.7; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3267.012; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 3.2; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3391.817; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 41.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 214.932; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 628.315; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 36.2; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3931.977; Material Code: MM
2 x BIB.021 | Havnivå |  |  | 35-35-18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 35-35-18; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1840.156; Material Code: MM
19 x BIB.021 | Havnivå |  | Generic | 18-18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 18-18; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 483.315; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.0; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 4488.076; Material Code: MM
2 x BIB.021 | Havnivå |  |  | 35-35-18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 35-35-18; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1360.156; Material Code: MM
17 x BIB.021 | Havnivå |  | Generic | 18-18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 18-18; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 2.7; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 5589.384; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 41.1; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 5711.046; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.4; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 4387.679; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.7; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 4294.708; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 37.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 233.864; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 481.414; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.7; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1694.672; Material Code: MM
2 x BIB.021 | Havnivå |  |  | 42-42-18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 42-42-18; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 37.9; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2870.002; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1774.463; Material Code: MM
2 x BIB.021 | Havnivå |  |  | 42-42-18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 42-42-18; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2693.433; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 45.343; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 145.343; Material Code: MM
18 x BIB.021 | Havnivå |  | Generic | 22-22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 22-22; Insulation_thickness_mm [mm]: 30
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1834.311; Material Code: MM
12 x BIB.021 | Havnivå |  | Generic | 18-18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 18-18; Insulation_thickness_mm [mm]: 30
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.4; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1637.79; Material Code: MM
11 x BIB.021 | Havnivå |  | Generic | 18-18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 18-18; Insulation_thickness_mm [mm]: 30
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 36.1; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1246.029; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 866.029; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 451.344; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 421.875; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.1; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2920.097; Material Code: MM
40 x BIB.021 | Havnivå |  | Generic | 15-15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 15-15; Insulation_thickness_mm [mm]: 30
34 x BIB.021 | Havnivå |  | Generic | 15-15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 15-15; Insulation_thickness_mm [mm]: 30
18 x BIB.021 | Havnivå |  | Generic | 15-15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 15-15; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Havnivå |  |  | 22-22-18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 22-22-18; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå |  |  | 22-22-18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 22-22-18; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 365.894; Material Code: MM
18 x BIB.021 | Havnivå |  | Generic | 15-15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 15-15; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 121.35; Material Code: MM
BIB.021 | Havnivå |  |  | 15-15-15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 15-15-15; Insulation_thickness_mm [mm]: 30; National code: UB1
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 23.125; Material Code: MM
BIB.021 | Havnivå |  |  | 15-15-15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 15-15-15; Insulation_thickness_mm [mm]: 30; National code: UB1
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 23.125; Material Code: MM
6 x BIB.021 | Havnivå |  |  | 15-15-15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 15-15-15; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1110.917; Material Code: MM
6 x BIB.021 | Havnivå |  |  | 15-15-15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 15-15-15; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1110.917; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 36.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 403.097; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 606.077; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.9; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3834.492; Material Code: MM
10 x BIB.021 | Havnivå |  | Generic | 28-28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 28-28; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
3 x BIB.021 | Havnivå |  |  | 28-28-18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 28-28-18; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 889.757; Material Code: MM
3 x BIB.021 | Havnivå |  |  | 28-28-18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 28-28-18; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 36.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 684.757; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1725.405; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1469.306; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.4; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2402; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 11 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 217.886; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 11 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2262; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 8.4; dpTot_SizingFlow_kPa [kPa]: 0.6; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 5952.116; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 35.8; dpTot_SizingFlow_kPa [kPa]: 0.5; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 5654.116; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 9.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 55; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 9.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 105; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 9.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 38.844; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 9.1; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2240; Material Code: MM
