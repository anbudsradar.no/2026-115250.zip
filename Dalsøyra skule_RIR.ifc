Properties of the parts of a building model (IFC2X3), part 9 of 14

# IfcCovering: BIB.021 (1891)
Name | In | MagiCAD Pset_Pipe, User Code | MagiCAD Pset_Pipe, Manufacturer | ConnectionSize_DN | Insulation_thickness_mm | SystemType | SystemName | SystemClass | MagiCAD Pset_Pipe, Insulation Material Code
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 63.672; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 53.506; Material Code: MM DN
5 x BIB.021 | Havnivå |  |  | 18-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 18-15; Insulation_thickness_mm [mm]: 12; National code: UB1; Product variable 4: 2
5 x BIB.021 | Havnivå |  |  | 18-15 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Reduction - ConnectionSize: 18-15; Insulation_thickness_mm [mm]: 12; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 0.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 382.5; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 44.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 627.343; Material Code: MM DN
BIB.021 | Havnivå |  |  | 15-15-15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 15-15-15; Insulation_thickness_mm [mm]: 30; National code: UB1
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 290.06; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 26.393; Material Code: Cu
8 x BIB.021 | Havnivå |  |  | 35-32 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Reduction - ConnectionSize: 35-32; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 73.046; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 422.916; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 570; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 358.221; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 800; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 1370; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 325; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 476.779; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 159.685; Material Code: Cu
BIB.021 | Havnivå |  |  | 32-15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Reduction - ConnectionSize: 32-15; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 18.834; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 73.412; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 40.518; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 12.313; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 75.756; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 92.279; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 8.388; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 155.301; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 69.448; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 86.471; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 58.067; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 33.355; Material Code: Cu
BIB.021 | Havnivå |  |  | 35-32 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 1 | Domestic Hot Water | MagiCAD Pset_Reduction - ConnectionSize: 35-32; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 73.241; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 37.9; dpTot_SizingFlow_kPa [kPa]: 31.2; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 68.512; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 37.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 256.658; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 6.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå |  | Generic | 42-40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Reduction - Description: MagiCAD - default reduction; ConnectionSize: 42-40; Insulation_thickness_mm [mm]: 30; National code: UB3
4 x BIB.021 | Havnivå |  | Generic | 42-40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Reduction - Description: MagiCAD - default reduction; ConnectionSize: 42-40; Insulation_thickness_mm [mm]: 30; National code: UB3
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 191.659; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 88.204; Material Code: MM DN
2 x BIB.021 | Havnivå |  |  | 22-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 22-15; Insulation_thickness_mm [mm]: 12; National code: UB1; Product variable 4: 2
2 x BIB.021 | Havnivå |  |  | 22-15 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Reduction - ConnectionSize: 22-15; Insulation_thickness_mm [mm]: 12; National code: UB1; Product variable 4: 2
4 x BIB.021 | Havnivå |  |  | 22-20 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Reduction - ConnectionSize: 22-20; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå |  |  | 28-15 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 28-15; Insulation_thickness_mm [mm]: 13; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå |  |  | 28-15 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Reduction - ConnectionSize: 28-15; Insulation_thickness_mm [mm]: 13; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 38.8; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2085.474; Material Code: MM
BIB.021 | Havnivå |  |  | 35-28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 35-28; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå |  |  | 35-28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 35-28; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
4 x BIB.021 | Havnivå |  |  | 18-15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Reduction - ConnectionSize: 18-15; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
2 x BIB.021 | Havnivå |  | Generic | 80-50 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Reduction - Description: MagiCAD - default reduction; ConnectionSize: 80-50; Insulation_thickness_mm [mm]: 30; National code: UB3
6 x BIB.021 | Havnivå |  | Generic | 80-65 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Reduction - Description: MagiCAD - default reduction; ConnectionSize: 80-65; Insulation_thickness_mm [mm]: 30; National code: UB3
BIB.021 | Havnivå |  | Generic | 80-42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Reduction - Description: MagiCAD - default reduction; ConnectionSize: 80-42; Insulation_thickness_mm [mm]: 30; National code: UB3
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 989.235; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 168.774; Material Code: MM DN
4 x BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 30; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå |  | Generic | 80-65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Reduction - Description: MagiCAD - default reduction; ConnectionSize: 80-65; Insulation_thickness_mm [mm]: 30; National code: UB3
BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 136.771; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 36.309; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 284.859; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 30; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
2 x BIB.021 | Havnivå |  |  | 22-20 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 22-20; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 862.104; Material Code: MM
2 x BIB.021 | Havnivå |  |  | 22-20 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - ConnectionSize: 22-20; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 743.534; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 30; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 287.918; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 30; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.005 | Generic | 10 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 5; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 10 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 5; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 35.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 208.499; Material Code: MM
12 x BIB.021 | Havnivå |  |  | 22-15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 22-15; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.004 | Generic | 12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 13.55; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 38.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM DN; MagiCAD Pset_Water - Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 21.5; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 10 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 38.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM DN; MagiCAD Pset_Water - Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 4.3; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 38.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 37.052; Material Code: MM
BIB.021 | Havnivå |  | Generic | 15-15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Joint - Description: Mapress CS Muffe; ConnectionSize: 15-15; Insulation_thickness_mm [mm]: 30; National code: UB3
BIB.021 | Havnivå | KRA.005 | Generic | 10 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM DN; MagiCAD Pset_Water - Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 11; Material Code: MM DN
BIB.021 | Havnivå |  | Generic | 12-10 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - Description: MagiCAD - default reduction; ConnectionSize: 12-10; Insulation_thickness_mm [mm]: 30; National code: UB3
2 x BIB.021 | Havnivå |  |  | 28-20 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 28-20; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
36 x BIB.021 | Havnivå |  |  | 15-10 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 15-10; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.2; dpTot_SizingFlow_kPa [kPa]: 0.5; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1338.129; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3260; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3260; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1384; Material Code: MM
BIB.021 | Plan U1 | KRA.004 | Generic | 18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 460.896; Material Code: MM
BIB.021 | Plan U1 | KRA.004 | Generic | 18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 534.258; Material Code: MM
BIB.021 | Plan U1 | KRA.004 | Generic | 18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.2; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 4181.846; Material Code: MM
BIB.021 | Plan U1 | KRA.004 | Generic | 18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2254; Material Code: MM
3 x BIB.021 | Plan U1 |  | Generic | 18-18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 18-18; Insulation_thickness_mm [mm]: 12; Insulation Material Code: Cellegummi
BIB.021 | Plan U1 | KRA.004 | Generic | 18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2394; Material Code: MM
3 x BIB.021 | Plan U1 |  | Generic | 18-18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 18-18; Insulation_thickness_mm [mm]: 12; Insulation Material Code: Cellegummi
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.7; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3415.6; Material Code: MM
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3415.6; Material Code: MM
BIB.021 | Plan U1 | KRA.004 | Generic | 18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.5; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3440.229; Material Code: MM
BIB.021 | Plan U1 | KRA.004 | Generic | 18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.5; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3366.867; Material Code: MM
BIB.021 | Plan U1 | KRA.004 | Generic | 18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.7; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 4342.504; Material Code: MM
BIB.021 | Plan U1 |  |  | 28-28-28 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 28-28-28; Insulation_thickness_mm [mm]: 13; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.5; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3063.903; Material Code: MM
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 4434.979; Material Code: MM
BIB.021 | Plan U1 |  |  | 28-28-28 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 28-28-28; Insulation_thickness_mm [mm]: 13; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.5; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2928.3; Material Code: MM
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.6; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 4285.684; Material Code: MM
3 x BIB.021 | Plan U1 |  | Generic | 28-28 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 28-28; Insulation_thickness_mm [mm]: 13; Insulation Material Code: Cellegummi
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 85.864; Material Code: MM
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 221.467; Material Code: MM
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 |  | 320.004.04 Varme Tur 50° 2, 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.9; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2422; Material Code: MM
3 x BIB.021 | Plan U1 |  | Generic | 28-28 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 28-28; Insulation_thickness_mm [mm]: 13; Insulation Material Code: Cellegummi
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.7; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2162; Material Code: MM
BIB.021 | Plan U1 |  | Generic | 28-28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 28-28; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Plan U1 |  | Generic | 28-28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 28-28; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Plan U1 |  | Generic | 28-18 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - Description: Mapress CS Overgang; ConnectionSize: 28-18; Insulation_thickness_mm [mm]: 13; Insulation Material Code: Cellegummi
BIB.021 | Plan U1 |  | Generic | 28-18 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Reduction - Description: Mapress CS Overgang; ConnectionSize: 28-18; Insulation_thickness_mm [mm]: 13; Insulation Material Code: Cellegummi
BIB.021 | Plan U1 | KRA.004 | Generic | 18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 323.245; Material Code: MM
BIB.021 | Plan U1 | SPZ.001 | IMI | 15-15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 37.0; dpTot_SizingFlow_kPa [kPa]: 29.6; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 287.466; Material Code: MM
BIB.021 | Plan U1 | SPZ.001 | IMI | 20-20 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 37.2; dpTot_SizingFlow_kPa [kPa]: 30.2; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Plan U1 | KRA.004 | Generic | 18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 499.837; Material Code: MM
BIB.021 | Plan U1 | SMA.001 | Armatec | 15-15 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 7.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Plan U1 | KRA.004 | Generic | 18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 116.956; Material Code: MM
BIB.021 | Plan U1 | SMA.001 | Armatec | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 37.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 481.532; Material Code: MM
BIB.021 | Plan U1 | SMA.001 | Armatec | 25-25 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 6.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Plan U1 | KRA.004 | Generic | 28 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 103.066; Material Code: MM
BIB.021 | Plan U1 | SMA.001 | Armatec | 25-25 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 37.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
2 x BIB.021 | Plan U1 |  |  | 18-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 18-15; Insulation_thickness_mm [mm]: 12; National code: UB1; Product variable 4: 2
2 x BIB.021 | Plan U1 |  |  | 28-20 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 28-20; Insulation_thickness_mm [mm]: 13; National code: UB1; Product variable 4: 2

# IfcEnergyConversionDevice: CRC 53+1 MV (2)
In: Havnivå
Type - Description: Carisma CRC Fan Coil-Vert Cabinet-AC Motor-2 Coils; PredefinedType: WATERHEATINGCOIL
MagiCAD Pset_FanCoilUnit - Description: Carisma CRC Fan Coil-Vert Cabinet-AC Motor-2 Coils; User Code: LCZ.001; Manufacturer: Sabiana; ProductCode: CRC 53+1 MV; qv_SizingFlow_ls [m³/h]: 0; Object Variable 1: Viftekonvektor
Group: 320.003.05 Varme Retur 40°; 320.004.04 Varme Tur 50°

# IfcEnergyConversionDevice: WT-V 1000 FC (6 bar)
In: Havnivå
Type - Description: Buffertank that can be used to eg. increase the volume in the heating system.
MagiCAD Pset_HeatingCoolingPlant - Description: Buffertank that can be used to eg. increase the volume in the heating system.; User Code: NUB.001; Manufacturer: Thermia; Product Code: WT-V 1000 FC (6 bar)
Group: 320.003.05 Varme Retur 40°; 320.003.04 Varme Tur 60°; 320.002.05 Varme Retur 50°

# IfcFlowController, V 4.1 EC
In: Havnivå
Description: Cyclonic vacuum degasser, cooling insulation with condensation water protection; Group: 320.003.05 Varme Retur 40°
MagiCAD Pset_PipeComponent - Description: Cyclonic vacuum degasser, cooling insulation with condensation water protection; User Code: MLA.002; Manufacturer: IMI; ConnectionSize_mm: 20; Product Code: V 4.1 EC

# IfcFlowController: 1915-15 (2)
In: Havnivå
Type - Description: Sikkerhetsventil; PredefinedType: AIRRELEASE
MagiCAD Pset_Valve - Description: Sikkerhetsventil; Product variable 1: QVZ; Product variable 2: 001; Product variable 4: 4; User Code: QVZ.001; NationalCode: UC3.10002; Manufacturer: SYR; Insulation_thickness_mm [mm]: 0; Product Code: 1915-15; ConnectionSize: 15-15
Group: 320.003.04 Varme Tur 60°

# IfcFlowController: 43350-228380 DN80 (2)
In: Havnivå
Type - Description: Check valve, double door, PN25
MagiCAD Pset_Valve - Description: Check valve, double door, PN25; User Code: SGB.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 30; Product Code: 43350-228380 DN80; ConnectionSize: 80-80
Group: 320.003.04 Varme Tur 60°

# IfcFlowController: AT1159-15 (2)
In: Havnivå
Type - Description: Tilbakeslagsventil; PredefinedType: CHECK
MagiCAD Pset_Valve - Description: Tilbakeslagsventil; Product variable 1: SGB; Product variable 2: 001; Product variable 4: 4; User Code: SGB.001; NationalCode: UC4; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 0; Product Code: AT1159-15; ConnectionSize: 15-15
Group: 312.002.01 VVC

# IfcFlowController: AT1159-32
In: Havnivå
Type - Description: Tilbakeslagsventil; PredefinedType: CHECK
MagiCAD Pset_Valve - Description: Tilbakeslagsventil; Product variable 1: SGB; Product variable 2: 001; Product variable 4: 4; User Code: SGB.001; NationalCode: UC4; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 0; Product Code: AT1159-32; ConnectionSize: 32-32
Group: 311.001.01 KV Forbruksvann

# IfcFlowController: AT1159-40 (2)
In: Havnivå
Type - Description: Tilbakeslagsventil; PredefinedType: CHECK
MagiCAD Pset_Valve - Description: Tilbakeslagsventil; Product variable 1: SGB; Product variable 2: 001; Product variable 4: 4; User Code: SGB.001; NationalCode: UC4; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 0; Product Code: AT1159-40; ConnectionSize: 40-40
Group: 320.003.04 Varme Tur 60°

# IfcFlowController: AT3600-15 (90)
Type - Description: Kuleventil, kort spindel; PredefinedType: REGULATING
MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; User Code: SMA.001; NationalCode: UC1.30001; Manufacturer: Armatec; Product Code: AT3600-15; ConnectionSize: 15-15
Name | In | Insulation_thickness_mm [mm] | pTot_SizingFlow_kPa [kPa] | dpTot_SizingFlow_kPa [kPa] | Insulation Material Code | Group
AT3600-15 | Havnivå | 11 | 6.5 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
2 x AT3600-15 | Havnivå | 0 | 37.5 | 0.0 |  | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 6.5 | 0.0 |  | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 6.7 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 37.4 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 11 | 37.1 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 11 | 7.0 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 6.0 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 12 | 37.9 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 5.5 | 0.0 |  | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 38.5 | 0.0 |  | 320.004.04 Varme Tur 50°
2 x AT3600-15 | Havnivå | 0 | 38.5 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
2 x AT3600-15 | Havnivå | 0 | 5.3 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 38.7 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 5.2 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 39.3 | 0.0 |  | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 4.7 | 0.0 |  | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 40.7 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 3.2 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 40.8 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 3.0 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 1.2 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 42.4 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 1.3 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 42.3 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 41.0 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
2 x AT3600-15 | Havnivå | 0 | 2.8 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 41.1 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
2 x AT3600-15 | Havnivå | 0 | 2.9 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
2 x AT3600-15 | Havnivå | 0 | 40.9 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 40.5 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 3.4 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 40.1 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 3.8 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 39.9 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 4.0 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
2 x AT3600-15 | Havnivå | 0 | 38.1 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
2 x AT3600-15 | Havnivå | 0 | 5.8 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 6.3 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 37.7 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 37.8 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 6.2 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 6.5 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 37.5 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 36.4 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 7.7 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 39.2 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 4.8 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 36.9 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 0 | 7.2 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 7.3 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 0 | 36.8 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 12 | 7.7 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 12 | 36.4 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
2 x AT3600-15 | Havnivå | 11 | 8.3 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
3 x AT3600-15 | Havnivå | 11 | 35.9 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 11 | 36.0 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 11 | 8.2 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 11 | 8.4 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 12 | 8.6 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 12 | 35.7 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
2 x AT3600-15 | Havnivå | 11 | 8.5 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 11 | 35.8 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 11 | 35.7 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 12 | 8.0 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 12 | 36.1 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 11 | 42.2 | 0.0 |  | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 11 | 1.4 | 0.0 |  | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 11 | 42.4 | 0.0 |  | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 11 | 1.2 | 0.0 |  | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 11 | 38.2 | 0.0 |  | 320.004.04 Varme Tur 50°
AT3600-15 | Havnivå | 11 | 5.7 | 0.0 |  | 320.003.05 Varme Retur 40°
2 x AT3600-15 | Havnivå | 0 |  |  |  | 312.002.01 VVC
AT3600-15 | Havnivå | 30 |  |  | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Havnivå | 30 |  |  | Cellegummi | 320.004.04 Varme Tur 50°
AT3600-15 | Plan U1 | 12 | 7.0 | 0.0 | Cellegummi | 320.003.05 Varme Retur 40°
AT3600-15 | Plan U1 | 12 | 37.0 | 0.0 | Cellegummi | 320.004.04 Varme Tur 50°

# IfcFlowController: AT3600-20 (37)
In: Havnivå
Type - Description: Kuleventil, kort spindel; PredefinedType: REGULATING
MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; User Code: SMA.001; NationalCode: UC1.30001; Manufacturer: Armatec; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi
Name | Insulation_thickness_mm [mm] | pTot_SizingFlow_kPa [kPa] | dpTot_SizingFlow_kPa [kPa] | Group
AT3600-20 | 12 | 6.8 | 0.0 | 320.003.05 Varme Retur 40°
AT3600-20 | 12 | 37.2 | 0.0 | 320.004.04 Varme Tur 50°
2 x AT3600-20 | 12 | 4.7 | 0.0 | 320.003.05 Varme Retur 40°
AT3600-20 | 12 | 39.3 | 0.0 | 320.004.04 Varme Tur 50°
AT3600-20 | 12 | 39.9 | 0.0 | 320.004.04 Varme Tur 50°
AT3600-20 | 12 | 3.9 | 0.0 | 320.003.05 Varme Retur 40°
AT3600-20 | 12 | 40.2 | 0.0 | 320.004.04 Varme Tur 50°
AT3600-20 | 12 | 3.7 | 0.0 | 320.003.05 Varme Retur 40°
AT3600-20 | 12 | 3.1 | 0.0 | 320.003.05 Varme Retur 40°
AT3600-20 | 12 | 40.7 | 0.0 | 320.004.04 Varme Tur 50°
AT3600-20 | 12 | 41.6 | 0.0 | 320.004.04 Varme Tur 50°
2 x AT3600-20 | 12 | 2.1 | 0.0 | 320.003.05 Varme Retur 40°
AT3600-20 | 12 | 41.7 | 0.0 | 320.004.04 Varme Tur 50°
AT3600-20 | 12 | 39.1 | 0.0 | 320.004.04 Varme Tur 50°
AT3600-20 | 12 | 5.9 | 0.0 | 320.003.05 Varme Retur 40°
AT3600-20 | 12 | 38.0 | 0.0 | 320.004.04 Varme Tur 50°
AT3600-20 | 12 | 6.7 | 0.0 | 320.003.05 Varme Retur 40°
AT3600-20 | 12 | 37.3 | 0.0 | 320.004.04 Varme Tur 50°
2 x AT3600-20 | 12 | 36.5 | 0.0 | 320.004.04 Varme Tur 50°
2 x AT3600-20 | 12 | 7.7 | 0.0 | 320.003.05 Varme Retur 40°
AT3600-20 | 12 | 36.6 | 0.0 | 320.004.04 Varme Tur 50°
AT3600-20 | 12 | 7.6 | 0.0 | 320.003.05 Varme Retur 40°
AT3600-20 | 13 | 9.0 | 0.0 | 320.003.05 Varme Retur 40°
AT3600-20 | 12 | 35.3 | 0.0 | 320.004.04 Varme Tur 50°
AT3600-20 | 12 | 8.7 | 0.0 | 320.003.05 Varme Retur 40°
AT3600-20 | 12 | 35.5 | 0.0 | 320.004.04 Varme Tur 50°
AT3600-20 | 12 | 37.9 | 0.0 | 320.004.04 Varme Tur 50°
AT3600-20 | 12 | 6.0 | 0.0 | 320.003.05 Varme Retur 40°
4 x AT3600-20 | 30 |  |  | 320.003.05 Varme Retur 40°
AT3600-20 | 30 |  |  | 320.004.04 Varme Tur 50°

# IfcFlowController: AT3600-25 (10)
Type - Description: Kuleventil, kort spindel; PredefinedType: REGULATING
MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; User Code: SMA.001; NationalCode: UC1.30001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 13; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi
Name | In | pTot_SizingFlow_kPa [kPa] | Group
AT3600-25 | Havnivå | 39.4 | 320.004.04 Varme Tur 50°
AT3600-25 | Havnivå | 4.4 | 320.003.05 Varme Retur 40°
AT3600-25 | Havnivå | 5.2 | 320.003.05 Varme Retur 40°
AT3600-25 | Havnivå | 38.8 | 320.004.04 Varme Tur 50°
AT3600-25 | Havnivå | 7.7 | 320.003.05 Varme Retur 40°
AT3600-25 | Havnivå | 36.5 | 320.004.04 Varme Tur 50°
AT3600-25 | Havnivå | 5.8 | 320.003.05 Varme Retur 40°
AT3600-25 | Havnivå | 38.1 | 320.004.04 Varme Tur 50°
AT3600-25 | Plan U1 | 6.7 | 320.003.05 Varme Retur 40°
AT3600-25 | Plan U1 | 37.2 | 320.004.04 Varme Tur 50°

# IfcFlowController: AT3600-32 (3)
In: Havnivå
Type - Description: Kuleventil, kort spindel; PredefinedType: REGULATING
MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; User Code: SMA.001; NationalCode: UC1.30001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 0; Product Code: AT3600-32; ConnectionSize: 32-32
Group: 312.001.01 VV Forbruksvann

# IfcFlowController: AT3600-40 (12)
In: Havnivå
Type - Description: Kuleventil, kort spindel; PredefinedType: REGULATING
MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; User Code: SMA.001; NationalCode: UC1.30001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 0; Product Code: AT3600-40; ConnectionSize: 40-40
Name | Group
