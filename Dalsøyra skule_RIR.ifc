Properties of the parts of a building model (IFC2X3), part 12 of 14

# IfcFlowSegment: Pressfittingssystem MM (1038)
Name | In | v_SizingFlow_ms [m/s] | pTot_SizingFlow_kPa [kPa] | dpTot_SizingFlow_kPa [kPa] | MagiCAD Pset_Heating, Insulation Material Code = MagiCAD Pset_Pipe, Insulation Material Code | ConnectionSize_DN | Insulation_thickness_mm [mm] | Length_mm | SystemType | SystemName | SystemClass | MagiCAD Pset_Water, Insulation Material Code | Material Code | Group
Pressfittingssystem MM | Havnivå | 0.2 | 6.2 | 0.1 |  | 18 | 0 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.5 | 0.1 |  | 18 | 0 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 37.9 | 0.0 | Cellegummi | 22 | 30 | 361 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.4 | 0.0 |  | 18 | 0 | 467 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.4 | 0.0 |  | 18 | 0 | 467 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.5 | 0.0 | Cellegummi | 18 | 12 | 28 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.3 | 0.0 | Cellegummi | 18 | 12 | 107 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.1 | 0.0 | Cellegummi | 18 | 30 | 56 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.1 | 0.2 | Cellegummi | 18 | 12 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.7 | 0.2 | Cellegummi | 18 | 12 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.7 | 0.0 | Cellegummi | 18 | 30 | 41 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 851 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 9 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 37.9 | 0.0 | Cellegummi | 18 | 30 | 110 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 38.4 | 0.5 | Cellegummi | 28 | 30 | 13062 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.5 | 0.5 | Cellegummi | 28 | 30 | 13072 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.6 | 0.1 | Cellegummi | 18 | 30 | 2844 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.1 | 0.1 | Cellegummi | 18 | 30 | 2712 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.6 | 0.0 | Cellegummi | 22 | 30 | 162 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.1 | 0.0 | Cellegummi | 22 | 30 | 308 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 37.3 | 0.2 | Cellegummi | 18 | 30 | 2900 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.3 | 0.0 |  | 18 | 0 | 380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.4 | 0.1 |  | 18 | 0 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.2 | 0.0 |  | 18 | 0 | 460 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 7.0 | 0.1 |  | 18 | 0 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1150 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 11 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1150 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 10 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1150 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 12 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1150 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 11 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.2 | 37.4 | 0.1 | Cellegummi | 18 | 30 | 2226 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 37.5 | 0.0 | Cellegummi | 22 | 30 | 556 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.8 | 0.2 | Cellegummi | 18 | 30 | 3048 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.7 | 0.1 | Cellegummi | 18 | 30 | 2406 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.6 | 0.0 | Cellegummi | 22 | 30 | 381 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.7 | 0.0 | Cellegummi | 15 | 30 | 51 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 7.1 | 0.2 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.7 | 0.2 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 38.5 | 0.0 | Cellegummi | 15 | 30 | 148 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.3 | 0.0 | Cellegummi | 15 | 30 | 161 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 5.8 | 0.2 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.6 | 0.0 |  | 15 | 0 | 354 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.4 | 0.2 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 5.6 | 0.0 |  | 15 | 0 | 434 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 38.6 | 0.1 | Cellegummi | 42 | 30 | 1742 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.5 | 5.2 | 0.1 | Cellegummi | 42 | 30 | 2105 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 37.5 | 0.0 |  | 15 | 30 | 36 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.5 | 0.0 |  | 15 | 30 | 134 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.9 | 0.2 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.7 | 0.0 |  | 15 | 0 | 381 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.5 | 0.2 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.7 | 0.0 |  | 15 | 0 | 431 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.2 | 0.3 | Cellegummi | 22 | 30 | 3427 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 37.8 | 0.0 | Cellegummi | 28 | 30 | 473 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.2 | 0.0 | Cellegummi | 35 | 30 | 514 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.1 | 0.0 |  | 22 | 0 | 347 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.2 | 0.1 |  | 22 | 0 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.9 | 0.0 |  | 22 | 0 | 434 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.8 | 0.1 |  | 22 | 0 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.6 | 0.2 | Cellegummi | 22 | 30 | 3441 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1065 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 13 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1065 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 12 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1235 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 14 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1235 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 13 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1105 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 15 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1105 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 14 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1195 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 16 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1195 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 15 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 37.5 | 0.0 |  | 18 | 30 | 76 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.0 | 0.0 |  | 18 | 0 | 507 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.2 | 0.2 |  | 18 | 0 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.8 | 0.1 |  | 18 | 0 | 507 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.6 | 0.2 |  | 18 | 0 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.5 | 0.0 | Cellegummi | 18 | 30 | 200 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1150 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 19 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1150 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 18 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1150 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 21 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1150 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 20 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 7.0 | 0.0 |  | 18 | 0 | 38 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.8 | 0.0 |  | 18 | 0 | 98 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 37.5 | 0.0 |  | 18 | 30 | 136 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 37.8 | 0.3 | Cellegummi | 22 | 30 | 3477 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1150 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 17 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1150 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 16 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.1 | 5.5 | 0.0 |  | 15 | 0 | 41 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.5 | 0.0 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.5 | 0.0 |  | 15 | 0 | 91 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 5.5 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 38.5 | 0.0 |  | 15 | 30 | 184 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.5 | 0.0 |  | 15 | 30 | 250 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 5.3 | 0.1 | Cellegummi | 42 | 30 | 1872 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 38.6 | 0.1 | Cellegummi | 42 | 30 | 1646 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.4 | 0.0 |  | 15 | 0 | 31 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.6 | 0.1 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.3 | 0.0 |  | 15 | 0 | 91 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.1 | 0.1 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.1 | 0.0 | Cellegummi | 15 | 30 | 346 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.6 | 0.0 | Cellegummi | 18 | 30 | 40 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 39.2 | 0.0 | Cellegummi | 18 | 30 | 224 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.8 | 0.0 | Cellegummi | 18 | 30 | 411 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 5.0 | 0.1 |  | 18 | 0 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.9 | 0.0 |  | 18 | 0 | 857 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.8 | 0.1 |  | 18 | 0 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 4.9 | 0.0 |  | 18 | 0 | 907 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.6 | 39.6 | 0.2 | Cellegummi | 54 | 30 | 2886 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.7 | 0.0 |  | 15 | 30 | 119 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 39.3 | 0.0 |  | 15 | 30 | 103 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.1 | 0.1 |  | 15 | 0 | 918 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.3 | 0.2 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.9 | 0.1 |  | 15 | 0 | 968 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 4.7 | 0.2 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 4.6 | 0.0 | Cellegummi | 15 | 30 | 370 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 4.4 | 0.2 | Cellegummi | 28 | 30 | 6547 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 39.4 | 0.0 | Cellegummi | 15 | 30 | 520 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.0 | 0.0 | Cellegummi | 22 | 12 | 146 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.2 | 0.1 | Cellegummi | 22 | 12 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.9 | 0.0 | Cellegummi | 22 | 12 | 206 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 4.8 | 0.1 | Cellegummi | 22 | 12 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 515 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 22 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 515 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 19 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 515 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 23 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 515 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 21 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 5.2 | 0.0 | Cellegummi | 22 | 30 | 297 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 39.6 | 0.2 | Cellegummi | 28 | 30 | 6634 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.6 | 0.1 | Cellegummi | 22 | 30 | 845 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 39.4 | 0.1 | Cellegummi | 22 | 30 | 918 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.2 | 0.0 | Cellegummi | 22 | 30 | 50 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.7 | 0.0 | Cellegummi | 22 | 30 | 10 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 4.7 | 0.0 | Cellegummi | 22 | 30 | 347 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 4.5 | 0.2 |  | 22 | 0 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.0 | 0.2 |  | 22 | 0 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 40.0 | 0.1 | Cellegummi | 22 | 30 | 759 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.6 | 0.0 |  | 22 | 30 | 122 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 3.9 | 0.0 | Cellegummi | 22 | 30 | 647 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 4.0 | 0.0 |  | 22 | 30 | 22 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 4.0 | 0.0 |  | 22 | 0 | 275 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 3.9 | 0.0 |  | 22 | 0 | 375 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 4.2 | 0.1 |  | 22 | 0 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 40.2 | 0.0 | Cellegummi | 22 | 30 | 284 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 3.7 | 0.1 |  | 22 | 0 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 3.7 | 0.0 | Cellegummi | 22 | 30 | 286 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 374 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 25 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 374 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 25 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.2 | 3.2 | 0.0 | Cellegummi | 18 | 30 | 254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 3.5 | 0.0 | Cellegummi | 18 | 30 | 351 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.4 | 0.0 | Cellegummi | 18 | 12 | 191 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.5 | 0.1 | Cellegummi | 18 | 12 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.3 | 0.0 | Cellegummi | 18 | 12 | 241 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 3.2 | 0.1 | Cellegummi | 18 | 12 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 40.8 | 0.1 | Cellegummi | 18 | 30 | 2282 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.1 | 0.1 | Cellegummi | 18 | 30 | 2120 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 4.6 | 0.1 | Cellegummi | 22 | 30 | 1339 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 39.2 | 0.1 | Cellegummi | 22 | 30 | 1207 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 39.1 | 0.0 | Cellegummi | 28 | 30 | 519 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 4.6 | 0.3 | Cellegummi | 35 | 30 | 4444 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.6 | 0.3 | Cellegummi | 22 | 30 | 3662 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 604 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 27 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 604 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 27 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 6.3 | 0.0 |  | 22 | 0 | 205 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.1 | 0.0 |  | 22 | 0 | 305 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.9 | 0.2 |  | 22 | 0 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.5 | 0.2 |  | 22 | 0 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.0 | 0.0 | Cellegummi | 18 | 30 | 379 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 4.2 | 0.1 | Cellegummi | 18 | 12 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.0 | 0.1 | Cellegummi | 18 | 12 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 38.5 | 0.0 | Cellegummi | 18 | 30 | 374 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.3 | 0.0 | Cellegummi | 18 | 30 | 335 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 5.5 | 0.1 | Cellegummi | 18 | 12 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.5 | 0.0 | Cellegummi | 18 | 12 | 217 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.4 | 0.1 | Cellegummi | 18 | 12 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 5.4 | 0.0 | Cellegummi | 18 | 12 | 267 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 |  | 15 | 0 | 61 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
3 x Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.7 | 0.0 |  | 15 | 0 | 151 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
2 x Pressfittingssystem MM | Havnivå | 0.1 | 5.7 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 38.3 | 0.1 | Cellegummi | 15 | 30 | 3740 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.6 | 0.1 | Cellegummi | 15 | 30 | 3838 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 5.7 | 0.0 |  | 15 | 0 | 131 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.7 | 0.0 |  | 15 | 0 | 181 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 5.7 | 0.0 |  | 15 | 30 | 122 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.1 | 0.0 |  | 18 | 0 | 127 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.3 | 0.2 |  | 18 | 0 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.1 | 0.0 |  | 18 | 0 | 217 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.9 | 0.2 |  | 18 | 0 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 515 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 34 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 515 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 33 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 5.4 | 0.2 | Cellegummi | 28 | 30 | 3522 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 4.9 | 0.4 | Cellegummi | 28 | 30 | 5155 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 38.6 | 0.2 | Cellegummi | 28 | 30 | 3610 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 39.0 | 0.4 | Cellegummi | 28 | 30 | 5205 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 39.3 | 0.2 | Cellegummi | 35 | 30 | 4136 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.9 | 0.0 | Cellegummi | 28 | 30 | 431 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.3 | 0.0 | Cellegummi | 28 | 30 | 47 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 38.6 | 0.0 | Cellegummi | 28 | 30 | 187 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 38.4 | 0.3 | Cellegummi | 18 | 30 | 3604 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.6 | 0.3 | Cellegummi | 18 | 30 | 3461 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 |  | 15 | 30 | 222 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.8 | 0.0 | Cellegummi | 15 | 30 | 1439 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 5.7 | 0.0 | Cellegummi | 15 | 30 | 1479 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 38.3 | 0.3 | Cellegummi | 22 | 30 | 3725 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 38.3 | 0.0 | Cellegummi | 22 | 30 | 391 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.6 | 0.0 | Cellegummi | 22 | 30 | 201 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 38.4 | 0.0 | Cellegummi | 22 | 30 | 117 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 5.6 | 0.0 | Cellegummi | 22 | 30 | 107 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 9.4 | 0.0 | Cellegummi | 18 | 12 | 157 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 9.6 | 0.2 | Cellegummi | 18 | 12 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 9.3 | 0.0 | Cellegummi | 18 | 12 | 217 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 9.1 | 0.2 | Cellegummi | 18 | 12 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 9.7 | 0.0 | Cellegummi | 18 | 30 | 334 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 9.0 | 0.0 | Cellegummi | 18 | 30 | 254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 9.8 | 0.0 | Cellegummi | 18 | 30 | 83 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 10.1 | 0.0 | Cellegummi | 18 | 12 | 136 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 10.0 | 0.0 | Cellegummi | 18 | 12 | 226 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 9.8 | 0.2 | Cellegummi | 18 | 12 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 10.3 | 0.2 | Cellegummi | 18 | 12 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 10.4 | 0.0 | Cellegummi | 18 | 30 | 334 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 10.4 | 0.0 | Cellegummi | 18 | 30 | 26 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.3 | 0.0 | Cellegummi | 18 | 30 | 16 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 10.4 | 0.7 | Cellegummi | 18 | 30 | 7735 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.3 | 0.7 | Cellegummi | 18 | 30 | 7545 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 39.0 | 0.1 | Cellegummi | 28 | 30 | 2059 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 4.9 | 0.1 | Cellegummi | 28 | 30 | 2059 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.1 | 0.0 | Cellegummi | 28 | 13 | 518 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.6 | 0.0 | Cellegummi | 28 | 13 | 568 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 5.2 | 0.1 | Cellegummi | 28 | 13 | 2362 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 5.2 | 0.0 | Cellegummi | 28 | 30 | 178 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.4 | 0.1 | Cellegummi | 28 | 13 | 2222 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 4.4 | 0.0 | Cellegummi | 28 | 30 | 76 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 690 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 31 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 690 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 31 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 685 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 30 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 689 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 30 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.2 | 40.0 | 0.0 | Cellegummi | 18 | 30 | 231 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.8 | 0.1 |  | 28 | 0 | 1463 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.9 | 0.1 |  | 28 | 0 | 1563 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 9.0 | 0.1 |  | 28 | 0 | 2362 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.7 | 0.1 |  | 28 | 0 | 2222 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.7 | 0.0 | Cellegummi | 28 | 30 | 455 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 389 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 29 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 389 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 29 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 189 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 32 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 189 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 32 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 359 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 33 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 359 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 34 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1424 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 32 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1419 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 32 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 7.6 | 0.0 | Cellegummi | 22 | 30 | 287 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 8.4 | 0.0 | Cellegummi | 22 | 30 | 94 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.2 | 0.1 |  | 22 | 0 | 1128 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.4 | 0.2 |  | 22 | 0 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.9 | 0.1 |  | 22 | 0 | 1245 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 335 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 36 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 330 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 36 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 7.6 | 0.0 | Cellegummi | 28 | 30 | 316 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.3 | 0.3 | Cellegummi | 35 | 30 | 7795 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 36.5 | 0.0 | Cellegummi | 28 | 30 | 281 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 36.6 | 0.0 | Cellegummi | 28 | 30 | 508 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 36.9 | 0.3 | Cellegummi | 35 | 30 | 7639 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 36.6 | 0.0 | Cellegummi | 22 | 30 | 315 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.8 | 0.0 | Cellegummi | 22 | 30 | 430 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 8.6 | 0.0 | Cellegummi | 22 | 30 | 567 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.3 | 0.1 |  | 22 | 0 | 1195 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.5 | 0.2 |  | 22 | 0 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.0 | 0.1 |  | 22 | 0 | 1245 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.8 | 0.2 |  | 22 | 0 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 335 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 37 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 330 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 37 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.2 | 7.3 | 0.4 | Cellegummi | 18 | 30 | 6188 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 36.8 | 0.4 | Cellegummi | 18 | 30 | 6136 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.0 | 0.0 |  | 18 | 0 | 156 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.9 | 0.0 |  | 18 | 0 | 251 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.8 | 0.0 |  | 22 | 30 | 345 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.4 | 0.0 |  | 22 | 30 | 436 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.2 | 0.0 |  | 22 | 0 | 56 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 318 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 40 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 318 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 39 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1738 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 40 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1738 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 39 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 7.4 | 0.2 |  | 22 | 0 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.0 | 0.0 |  | 22 | 0 | 117 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.8 | 0.2 |  | 22 | 0 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.2 | 0.0 |  | 22 | 0 | 70 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.0 | 0.0 |  | 22 | 0 | 70 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.8 | 0.1 |  | 18 | 0 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.7 | 0.0 |  | 18 | 0 | 220 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.5 | 0.1 |  | 18 | 0 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.6 | 0.0 |  | 18 | 0 | 305 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 37.6 | 0.1 | Cellegummi | 18 | 30 | 1691 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.4 | 0.1 | Cellegummi | 18 | 30 | 1584 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.2 | 0.1 | Cellegummi | 28 | 30 | 2149 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 36.9 | 0.1 | Cellegummi | 28 | 30 | 2154 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.5 | 6.4 | 0.7 | Cellegummi | 35 | 30 | 8128 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.2 | 0.1 | Cellegummi | 35 | 30 | 2041 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.5 | 37.7 | 0.7 | Cellegummi | 35 | 30 | 7942 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 37.8 | 0.1 | Cellegummi | 15 | 30 | 1026 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.8 | 0.2 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.6 | 0.0 |  | 15 | 0 | 329 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.3 | 0.2 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.5 | 0.0 |  | 15 | 0 | 424 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 37.8 | 0.0 | Cellegummi | 15 | 30 | 313 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.5 | 37.9 | 0.0 | Cellegummi | 42 | 30 | 42 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.2 | 0.1 | Cellegummi | 15 | 30 | 1140 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
