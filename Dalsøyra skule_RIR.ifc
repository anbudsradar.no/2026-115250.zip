Properties of the parts of a building model (IFC2X3), part 3 of 14

# IfcCovering: BIB.021 (1891)
Name | In | MagiCAD Pset_Pipe, User Code | MagiCAD Pset_Pipe, Manufacturer | ConnectionSize_DN | Insulation_thickness_mm | SystemType | SystemName | SystemClass | MagiCAD Pset_Pipe, Insulation Material Code
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 4.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2254; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 38.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 374.005; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 335.1; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.5; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2394; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 217.281; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.4; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2254; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 267.281; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 38.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3739.8; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.6; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3837.846; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 122.035; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.4; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3522.194; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 4.9; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 5154.955; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 38.6; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3609.694; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 39.0; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 5204.955; Material Code: MM
4 x BIB.021 | Havnivå |  |  | 35-35-28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 35-35-28; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 39.3; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 4136.25; Material Code: MM
3 x BIB.021 | Havnivå |  |  | 35-35-28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 35-35-28; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 4.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 431.109; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 47.497; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 38.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 187.497; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 38.4; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3604.369; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.6; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3461.216; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 222.035; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1439.417; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1479.417; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 38.3; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3724.747; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 38.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 390.691; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 200.691; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 38.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 116.515; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 106.515; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 9.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 157.106; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 9.6; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2394; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 9.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 217.106; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 9.1; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2254; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 9.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 334; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 9.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 254; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 9.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 82.583; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 10.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 136.25; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 10.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 226.25; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 9.8; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2254; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 10.3; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2394; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 10.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 334; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 10.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 25.832; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 15.832; Material Code: MM
2 x BIB.021 | Havnivå |  |  | 28-28-28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 28-28-28; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 10.4; dpTot_SizingFlow_kPa [kPa]: 0.7; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 7735.123; Material Code: MM
2 x BIB.021 | Havnivå |  |  | 28-28-28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 28-28-28; Insulation_thickness_mm [mm]: 30; National code: UB1; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.3; dpTot_SizingFlow_kPa [kPa]: 0.7; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 7544.677; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 39.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2058.865; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 4.9; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2058.865; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 518.371; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 4.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 568.371; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.2; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2362; Material Code: MM
BIB.021 | Havnivå |  | Generic | 28-28 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 28-28; Insulation_thickness_mm [mm]: 13; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 177.873; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 4.4; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2222; Material Code: MM
BIB.021 | Havnivå |  | Generic | 28-28 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 28-28; Insulation_thickness_mm [mm]: 13; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 4.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 76.049; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 40.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 231.265; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 454.765; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 287.234; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 93.801; Material Code: MM
2 x BIB.021 | Havnivå |  | Generic | 28-28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 28-28; Insulation_thickness_mm [mm]: 30
2 x BIB.021 | Havnivå |  | Generic | 28-28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 28-28; Insulation_thickness_mm [mm]: 30
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 316.04; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.3; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 7794.681; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 281.39; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 508.09; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.9; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 7638.573; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 315.137; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 429.969; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 567.252; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.3; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6187.798; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 36.8; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6135.636; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 345.394; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 435.931; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.6; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1691.124; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.4; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1583.547; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.2; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2149.163; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.9; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2154.163; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 6.4; dpTot_SizingFlow_kPa [kPa]: 0.7; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 8128.327; Material Code: MM
BIB.021 | Havnivå |  | Generic | 35-35 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 35-35; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.2; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2041.4; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 35 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 37.7; dpTot_SizingFlow_kPa [kPa]: 0.7; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 7942.286; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.8; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1025.936; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 312.74; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 37.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 41.629; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1140.375; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 507.74; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 8.915; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 6.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1053.806; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 37.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1153.806; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 6.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 638.938; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 37.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 448.938; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 63.284; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 440.541; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 95.618; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 37.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 166.417; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 37.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 101.336; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 262; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 324.007; Material Code: MM
BIB.021 | Havnivå |  | Generic | 42-42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 42-42; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.005 | Generic | 50 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 39.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 120.49; Material Code: MM DN
BIB.021 | Havnivå |  | Generic | 42-42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 42-42; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 38.6; dpTot_SizingFlow_kPa [kPa]: 0.6; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 10173.74; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 362; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 5.4; dpTot_SizingFlow_kPa [kPa]: 0.7; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 10173.74; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 482.925; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.4; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 7128.38; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 424.007; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 38.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 502.689; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 38.5; dpTot_SizingFlow_kPa [kPa]: 0.3; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 7143.38; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1334.833; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 38.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1393.638; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 208.19; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 308.19; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 38.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 138.606; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 244.601; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 5.1; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2149.059; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 131.177; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.8; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2380; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 131.177; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.2; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2240; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 198.66; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 98.66; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 151.275; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 211.275; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 1.8; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 5097.851; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 42.0; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 5191.369; Material Code: MM
