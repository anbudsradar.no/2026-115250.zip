Properties of the parts of a building model (IFC2X3), part 8 of 14

# IfcCovering: BIB.021 (1891)
Name | In | MagiCAD Pset_Pipe, User Code | MagiCAD Pset_Pipe, Manufacturer | ConnectionSize_DN | Insulation_thickness_mm | SystemType | SystemName | SystemClass | MagiCAD Pset_Pipe, Insulation Material Code
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 42.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 42.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 166.777; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 1.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 1.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 792.04; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 2.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 40.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 16; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 40.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 89.997; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 40.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 3.795; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 3.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 38.2; dpTot_SizingFlow_kPa [kPa]: 32.5; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 223.738; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 38.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 38.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 121.269; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 5.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 511.96; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 38.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 152.194; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 16; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 38.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 85.666; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 11; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 38.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 6; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 37.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 11; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 12 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 16; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 10; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 295; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 8; Material Code: MM
9 x BIB.021 | Havnivå |  |  | 42-40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Reduction - ConnectionSize: 42-40; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1073.248; Material Code: MM
8 x BIB.021 | Havnivå |  | Generic | 42-42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 42-42; Insulation_thickness_mm [mm]: 30
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 185; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1046.3; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 8; Material Code: MM
9 x BIB.021 | Havnivå |  |  | 42-40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Reduction - ConnectionSize: 42-40; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 935.3; Material Code: MM
8 x BIB.021 | Havnivå |  | Generic | 42-42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 42-42; Insulation_thickness_mm [mm]: 30
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 185; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1346.342; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1346.3; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1046.3; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 43.8; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 5098.173; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 0.7; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1680; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 964.514; Material Code: MM DN
6 x BIB.021 | Havnivå |  | Generic | 40-40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 40-40; Insulation_thickness_mm [mm]: 30
11 x BIB.021 | Havnivå |  | Generic | 40-40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 40-40; Insulation_thickness_mm [mm]: 30
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1380.773; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 840; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1726.194; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1955.136; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1540; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 860; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1798.448; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2073.084; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 760; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 809.414; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1882.589; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1613.671; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 754.011; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1883.518; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1814.374; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 93.785; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 538.505; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 769.986; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1298.005; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 69.214; Material Code: MM
2 x BIB.021 | Havnivå |  |  | 42-32 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Reduction - ConnectionSize: 42-32; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 37.763; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 207.821; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 178.391; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 122.378; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 295.792; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 287.702; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 70.636; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 75.018; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 228.002; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 424.724; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 448.619; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 66.116; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 75.35; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 76.857; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 70.636; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 84.244; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 45.3; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 185; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 415.192; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 515.846; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 79.756; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 187.946; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 47.345; Material Code: MM DN
10 x BIB.021 | Havnivå | SMA.001 | Armatec | 80-80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 30; Product Code: AT3600-80; ConnectionSize: 80-80; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 56.238; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 56.571; Material Code: MM DN
2 x BIB.021 | Havnivå | SMA.001 | Armatec | 80-80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 30; Product Code: AT3600-80; ConnectionSize: 80-80; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 151.138; Material Code: MM DN
BIB.021 | Havnivå | RFB.001 | General | 80-80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_PipeComponent - Description: Vannmengdemåler; Product variable 1: RFB; Product variable 2: 001; Product variable 4: 4; User Code: RFB.001; NationalCode: UD1; Manufacturer: General; ConnectionSize_mm: 65; Product Code: FM-80
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 228.2; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 114.369; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 413.07; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 15.223; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 9.986; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 63.344; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 43.417; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 53.206; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 55.191; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 119.692; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 84.975; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 139.218; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 84.982; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 77.935; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 79.722; Material Code: MM DN
2 x BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 46.79; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 74.807; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 180.344; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1958.35; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 141.86; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1019.511; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 297; Material Code: MM DN
2 x BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 246.136; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 351.28; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 43.481; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 32.586; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 10; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 192.588; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 20 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 288.341; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 38.593; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 78.02; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 36.213; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 45.959; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 124.64; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 36.951; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 23.814; Material Code: MM DN
2 x BIB.021 | Havnivå | SGB.001 | IMI | 80-80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Valve - Description: Check valve, double door, PN25; User Code: SGB.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 30; Product Code: 43350-228380 DN80; ConnectionSize: 80-80
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 27.215; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1076.317; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 72.29; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1131.716; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 310.841; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 206.376; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 55.802; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 56.756; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 344.364; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 81.706; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 347.727; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 139.733; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 207.894; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 7087.956; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 0.2; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 5085.05; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 547.343; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 582.5; Material Code: MM DN
BIB.021 | Havnivå |  | Generic | 65-65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Elbow - Description: Mapress CS Bend; ConnectionSize: 65-65; Insulation_thickness_mm [mm]: 30
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 79.415; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 72.427; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 253.334; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 99.293; Material Code: MM DN
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 1 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 17.691; Material Code: Cu
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 132.598; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 141.299; Material Code: MM DN
BIB.021 | Havnivå |  |  | 55-35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 1 | Domestic Hot Water | MagiCAD Pset_Reduction - ConnectionSize: 55-35; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 1 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 1776.148; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 1 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 38.903; Material Code: Cu
2 x BIB.021 | Havnivå |  |  | 35-35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 1 | Domestic Hot Water | MagiCAD Pset_Elbow - Description: MagiCAD - default bend; ConnectionSize: 35-35; Insulation_thickness_mm [mm]: 30; Product variable 4: 2
BIB.021 | Havnivå | KRA.001 |  | 55 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: <By Category>; Length_mm: 19.191; Material Code: Cu
5 x BIB.021 | Havnivå |  |  | 35-35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Elbow - Description: MagiCAD - default bend; ConnectionSize: 35-35; Insulation_thickness_mm [mm]: 30; Product variable 4: 2
BIB.021 | Havnivå |  |  | 55-35 | 30 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water | MagiCAD Pset_Reduction - ConnectionSize: 55-35; Insulation_thickness_mm [mm]: 30; National code: UB1; Product variable 4: 2
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 41.82; Material Code: Cu
6 x BIB.021 | Havnivå |  |  | 15-15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Elbow - Description: MagiCAD - default bend; ConnectionSize: 15-15; Insulation_thickness_mm [mm]: 30; Product variable 4: 2
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 407.822; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 173.444; Material Code: Cu
BIB.021 | Havnivå | KRA.001 |  | 15 | 30 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2; MagiCAD Pset_Pipe - Material: Kobberrør; Length_mm: 28.517; Material Code: Cu
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 442.133; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 648.543; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 191.493; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 146.534; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 170.132; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 31.05; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 70.251; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 48.016; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 28.574; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 53.625; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 51.206; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 76.96; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 181.293; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 149.207; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 46.229; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 42 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 46.69; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 407.562; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 92.161; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1646.462; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 7271.24; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 128.439; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 97.294; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 105.369; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 40 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 51.993; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 80 | 30 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | MagiCAD Pset_Heating - Material Code: MM DN; sets with these values: 2; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 613.82; Material Code: MM DN
