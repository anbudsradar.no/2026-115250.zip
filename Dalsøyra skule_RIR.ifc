Properties of the parts of a building model (IFC2X3), part 11 of 14

# IfcFlowSegment: Pressfittingssystem DN (166)
Name | ConnectionSize_DN | Length_mm | SystemType = Group | SystemName | SystemClass | sets with these values
Pressfittingssystem DN | 65 | 1538 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 40.2; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 11266 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 4.0; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 11066 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 40.1; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1990 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 4.4; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1975 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 39.7; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1019 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 40.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 769 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 3.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 925 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 1.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1051 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 43.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1600 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 43.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 10 | 5 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 1.5; dpTot_SizingFlow_kPa [kPa]: 0.0; MagiCAD Pset_Water - Material Code: MM DN
Pressfittingssystem DN | 40 | 10 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 295 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 1046 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 1346 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 65 | 5098 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 43.8; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1680 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 0.7; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 40 | 965 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 760 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 809 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 1883 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 1614 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 754 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 1884 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 1814 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 539 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 770 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 1298 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 296 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 288 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 65 | 71 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 75 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 228 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 425 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 449 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 66 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 75 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 77 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 71 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 84 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 45 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 185 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 415 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 516 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 80 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 188 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 47 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 56 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 57 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 151 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 228 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 114 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 413 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 15 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 10 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 63 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
2 x Pressfittingssystem DN | 80 | 43 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 53 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 55 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 120 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
2 x Pressfittingssystem DN | 20 | 85 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 139 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 20 | 78 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 20 | 80 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
2 x Pressfittingssystem DN | 20 | 47 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 20 | 75 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 20 | 180 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 1958 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 142 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 1020 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 297 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
2 x Pressfittingssystem DN | 80 | 246 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 351 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 33 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 20 | 10 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 20 | 193 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 20 | 288 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 39 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 78 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 36 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 46 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 125 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 37 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 24 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 27 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 1076 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
2 x Pressfittingssystem DN | 80 | 72 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 65 | 1132 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 80 | 311 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 65 | 206 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 65 | 56 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 65 | 57 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 344 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 65 | 82 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 348 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 140 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 208 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 7088 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 65 | 5085 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 0.2; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 547 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2 | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi
Pressfittingssystem DN | 65 | 583 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | 2 | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi
Pressfittingssystem DN | 80 | 79 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 65 | 253 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 65 | 99 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 133 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 141 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 408 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 92 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 1646 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 7271 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 128 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 97 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 105 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 40 | 52 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 614 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 64 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 40 | 54 | 320.003.04 Varme Tur 60° | 320.003.04 Varme Tur 60° 1 | Hydronic Supply | 2
Pressfittingssystem DN | 65 | 383 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 0.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 627 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 44.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 192 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 65 | 88 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2
Pressfittingssystem DN | 80 | 989 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2 | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi
Pressfittingssystem DN | 20 | 169 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2 | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi
Pressfittingssystem DN | 20 | 137 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2 | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi
Pressfittingssystem DN | 20 | 36 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | 2 | MagiCAD Pset_Heating - Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi
Pressfittingssystem DN | 10 | 5 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 10 | 5 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | 2
Pressfittingssystem DN | 15 | 22 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 38.5; dpTot_SizingFlow_kPa [kPa]: 0.0; MagiCAD Pset_Water - Material Code: MM DN
Pressfittingssystem DN | 10 | 4 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 38.5; dpTot_SizingFlow_kPa [kPa]: 0.0; MagiCAD Pset_Water - Material Code: MM DN
Pressfittingssystem DN | 10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.5; dpTot_SizingFlow_kPa [kPa]: 0.0; MagiCAD Pset_Water - Material Code: MM DN

# IfcFlowSegment: Pressfittingssystem MM (1038)
Type - Description: Pressfittingssystem MM EN-10305; PredefinedType: RIGIDSEGMENT
Material: MM 0 mm
MagiCAD Pset_Heating - Material Code: MM
MagiCAD Pset_Pipe - User Code: KRA.004; Product variable 5: C; Product variable 4: 2; Product variable 3: mm; Product variable 2: 004; Manufacturer: Generic; Material: Pressfittingssystem MM; Product variable 1: KRA; NationalCode: UB3.11004400022; Description: Pressfittingssystem MM EN-10305; Material Code: MM
Name | In | v_SizingFlow_ms [m/s] | pTot_SizingFlow_kPa [kPa] | dpTot_SizingFlow_kPa [kPa] | MagiCAD Pset_Heating, Insulation Material Code = MagiCAD Pset_Pipe, Insulation Material Code | ConnectionSize_DN | Insulation_thickness_mm [mm] | Length_mm | SystemType | SystemName | SystemClass | MagiCAD Pset_Water, Insulation Material Code | Material Code | Group
Pressfittingssystem MM | Havnivå | 0.4 | 7.3 | 0.5 | Cellegummi | 35 | 30 | 6386 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 6.2 | 0.0 | Cellegummi | 28 | 30 | 478 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.6 | 4.8 | 0.3 | Cellegummi | 54 | 30 | 3738 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 4.0 | 0.1 | Cellegummi | 42 | 30 | 1196 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 39.9 | 0.1 | Cellegummi | 42 | 30 | 1138 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.5 | 38.9 | 0.2 | Cellegummi | 42 | 30 | 2429 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.6 | 39.4 | 0.3 | Cellegummi | 54 | 30 | 3788 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 36.9 | 0.5 | Cellegummi | 35 | 30 | 6591 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.6 | 4.5 | 0.9 | Cellegummi | 42 | 30 | 9405 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.6 | 39.5 | 0.9 | Cellegummi | 42 | 30 | 9325 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.8 | 0.5 | Cellegummi | 22 | 30 | 4393 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.6 | 5.1 | 1.8 | Cellegummi | 42 | 50 | 22973 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 37.2 | 0.5 | Cellegummi | 22 | 30 | 4284 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.6 | 39.1 | 1.7 | Cellegummi | 42 | 50 | 22973 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 4.1 | 0.3 | Cellegummi | 28 | 30 | 6677 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.5 | 4.1 | 0.5 | Cellegummi | 35 | 30 | 6516 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 39.7 | 0.3 | Cellegummi | 28 | 30 | 6814 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.5 | 39.8 | 0.5 | Cellegummi | 35 | 30 | 6514 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.3 | 0.4 | Cellegummi | 18 | 30 | 6441 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 36.8 | 0.4 | Cellegummi | 18 | 30 | 6261 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 35.8 | 0.0 | Cellegummi | 22 | 30 | 87 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.5 | 0.0 | Cellegummi | 22 | 30 | 4 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.4 | 0.3 | Cellegummi | 22 | 30 | 4104 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 36.7 | 0.3 | Cellegummi | 22 | 30 | 3983 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.5 | 0.1 | Cellegummi | 22 | 30 | 1758 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 8.6 | 0.2 | Cellegummi | 22 | 30 | 2503 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 35.8 | 0.1 | Cellegummi | 22 | 30 | 2158 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 36.3 | 0.1 | Cellegummi | 28 | 30 | 3354 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.1 | 0.2 | Cellegummi | 22 | 30 | 3175 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 35.9 | 0.0 | Cellegummi | 18 | 30 | 280 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.2 | 0.3 | Cellegummi | 28 | 30 | 6687 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 37.4 | 0.2 | Cellegummi | 22 | 30 | 3479 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 37.8 | 0.3 | Cellegummi | 28 | 30 | 6499 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.5 | 38.4 | 0.6 | Cellegummi | 35 | 30 | 6969 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.0 | 0.0 | Cellegummi | 18 | 30 | 134 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 5.5 | 0.1 | Cellegummi | 42 | 30 | 1501 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 5.0 | 0.2 | Cellegummi | 28 | 30 | 6013 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 39.0 | 0.2 | Cellegummi | 28 | 30 | 6105 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 37.1 | 0.0 | Cellegummi | 35 | 30 | 123 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 37.0 | 0.1 | Cellegummi | 35 | 30 | 2070 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.6 | 0.0 | Cellegummi | 22 | 30 | 213 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 37.0 | 0.0 | Cellegummi | 28 | 30 | 1046 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 36.8 | 0.1 | Cellegummi | 22 | 30 | 1685 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 36.7 | 0.2 | Cellegummi | 22 | 30 | 2956 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.2 | 0.0 | Cellegummi | 28 | 30 | 1008 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.3 | 0.1 | Cellegummi | 22 | 30 | 1610 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.5 | 0.2 | Cellegummi | 22 | 30 | 3022 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 40.7 | 0.2 | Cellegummi | 15 | 30 | 3267 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 3.2 | 0.3 | Cellegummi | 15 | 30 | 3392 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 41.1 | 0.0 | Cellegummi | 15 | 30 | 215 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 35.9 | 0.0 | Cellegummi | 15 | 30 | 628 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 36.2 | 0.2 | Cellegummi | 18 | 30 | 3932 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 36.3 | 0.1 | Cellegummi | 35 | 30 | 1840 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.3 | 0.0 | Cellegummi | 15 | 30 | 483 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 8.0 | 0.3 | Cellegummi | 18 | 30 | 4488 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.9 | 0.0 | Cellegummi | 35 | 30 | 1360 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 2.7 | 0.4 | Cellegummi | 22 | 30 | 5589 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 41.1 | 0.4 | Cellegummi | 22 | 30 | 5711 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 6.4 | 0.3 | Cellegummi | 22 | 30 | 4388 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 37.7 | 0.3 | Cellegummi | 22 | 30 | 4295 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 37.7 | 0.0 | Cellegummi | 42 | 30 | 234 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.4 | 0.0 | Cellegummi | 18 | 30 | 481 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 37.7 | 0.1 | Cellegummi | 18 | 30 | 1695 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 37.9 | 0.2 | Cellegummi | 42 | 30 | 2870 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.3 | 0.1 | Cellegummi | 18 | 30 | 1774 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 6.2 | 0.2 | Cellegummi | 42 | 30 | 2693 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 224 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 224 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 7.8 | 0.0 |  | 22 | 0 | 55 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.6 | 0.0 |  | 22 | 0 | 105 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.4 | 0.0 |  | 22 | 30 | 45 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 7.4 | 0.2 |  | 22 | 0 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 8.0 | 0.2 |  | 22 | 0 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.0 | 0.0 |  | 22 | 30 | 145 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.9 | 0.0 |  | 18 | 0 | 689 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 8.0 | 0.0 |  | 18 | 0 | 594 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
2 x Pressfittingssystem MM | Havnivå | 0.2 | 8.1 | 0.1 |  | 18 | 0 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
2 x Pressfittingssystem MM | Havnivå | 0.2 | 7.8 | 0.1 |  | 18 | 0 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 35.9 | 0.2 | Cellegummi | 18 | 30 | 1834 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.4 | 0.2 | Cellegummi | 18 | 30 | 1638 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 9.2 | 0.2 |  | 18 | 0 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.9 | 0.0 |  | 18 | 0 | 123 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.6 | 0.2 |  | 18 | 0 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 8.9 | 0.0 |  | 18 | 0 | 222 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 36.1 | 0.1 | Cellegummi | 18 | 30 | 1246 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.1 | 0.0 | Cellegummi | 18 | 30 | 866 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 8.7 | 0.2 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.5 | 0.0 |  | 15 | 0 | 117 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.3 | 0.2 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 8.5 | 0.0 |  | 15 | 0 | 212 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
2 x Pressfittingssystem MM | Havnivå | 0.1 | 8.5 | 0.0 |  | 15 | 0 | 66 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.5 | 0.0 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 35.9 | 0.0 | Cellegummi | 15 | 30 | 451 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
3 x Pressfittingssystem MM | Havnivå | 0.1 | 8.4 | 0.0 |  | 15 | 0 | 151 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 8.4 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 8.4 | 0.0 | Cellegummi | 15 | 30 | 422 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 36.1 | 0.2 | Cellegummi | 22 | 30 | 2920 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 35.9 | 0.0 | Cellegummi | 15 | 30 | 366 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.3 | 0.0 | Cellegummi | 15 | 30 | 121 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 8.4 | 0.0 |  | 15 | 0 | 66 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
2 x Pressfittingssystem MM | Havnivå | 0.1 | 8.5 | 0.0 |  | 15 | 0 | 2403 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
2 x Pressfittingssystem MM | Havnivå | 0.1 | 8.4 | 0.0 |  | 15 | 0 | 2263 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 8.5 | 0.0 |  | 15 | 30 | 23 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.4 | 0.0 |  | 15 | 30 | 23 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 8.5 | 0.0 | Cellegummi | 15 | 30 | 1111 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.4 | 0.0 | Cellegummi | 15 | 30 | 1111 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 36.8 | 0.0 | Cellegummi | 18 | 30 | 403 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.3 | 0.0 | Cellegummi | 18 | 30 | 606 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 7.5 | 0.1 |  | 18 | 0 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 7.3 | 0.1 |  | 18 | 0 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 7.4 | 0.0 |  | 18 | 0 | 319 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 7.9 | 0.1 | Cellegummi | 28 | 30 | 3834 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 8.1 | 0.0 | Cellegummi | 28 | 30 | 890 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 36.2 | 0.0 | Cellegummi | 28 | 30 | 685 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 35.9 | 0.1 | Cellegummi | 15 | 30 | 1725 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.3 | 0.1 | Cellegummi | 15 | 30 | 1469 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 8.9 | 0.2 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.7 | 0.0 |  | 15 | 0 | 77 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.5 | 0.2 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 8.7 | 0.0 |  | 15 | 0 | 167 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 8.4 | 0.1 | Cellegummi | 15 | 11 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.3 | 0.0 | Cellegummi | 15 | 11 | 218 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 8.3 | 0.0 | Cellegummi | 15 | 11 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 8.4 | 0.6 | Cellegummi | 22 | 30 | 5952 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 35.8 | 0.5 | Cellegummi | 22 | 30 | 5654 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 9.5 | 0.0 |  | 22 | 0 | 104 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 9.3 | 0.0 |  | 22 | 0 | 104 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 9.6 | 0.0 | Cellegummi | 22 | 12 | 55 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 9.3 | 0.0 | Cellegummi | 22 | 13 | 105 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 9.0 | 0.0 | Cellegummi | 22 | 30 | 39 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 9.1 | 0.2 | Cellegummi | 22 | 13 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 9.8 | 0.2 | Cellegummi | 22 | 12 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 9.9 | 0.0 | Cellegummi | 22 | 30 | 139 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 36.2 | 0.4 | Cellegummi | 28 | 30 | 4535 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 8.0 | 0.4 | Cellegummi | 28 | 30 | 4735 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 355 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 2 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 335 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 2 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 35.6 | 0.1 | Cellegummi | 22 | 30 | 2326 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 9.1 | 0.0 |  | 22 | 0 | 86 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 9.2 | 0.1 |  | 22 | 0 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.9 | 0.0 |  | 22 | 0 | 186 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 8.8 | 0.1 |  | 22 | 0 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 335 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 2 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 335 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 7.3 | 0.1 | Cellegummi | 28 | 30 | 1297 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 36.8 | 0.1 | Cellegummi | 28 | 30 | 1587 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.4 | 0.0 |  | 18 | 0 | 117 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.5 | 0.2 |  | 18 | 0 | 2394 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.3 | 0.0 |  | 18 | 0 | 217 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 8.1 | 0.2 |  | 18 | 0 | 2254 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 515 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 8 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 515 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 8 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.1 | 35.7 | 0.1 | Cellegummi | 15 | 30 | 2483 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.6 | 0.0 |  | 15 | 0 | 597 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.7 | 0.1 |  | 15 | 0 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.6 | 0.0 |  | 15 | 0 | 687 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 8.5 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 35.7 | 0.0 | Cellegummi | 15 | 30 | 89 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.5 | 0.0 | Cellegummi | 15 | 30 | 2605 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 8.5 | 0.0 | Cellegummi | 15 | 30 | 479 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 8.4 | 0.1 | Cellegummi | 22 | 30 | 1123 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.4 | 37.0 | 0.0 | Cellegummi | 42 | 30 | 346 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.4 | 7.3 | 0.0 | Cellegummi | 42 | 30 | 536 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 8.1 | 0.0 |  | 22 | 0 | 496 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 8.3 | 0.2 |  | 22 | 0 | 2380 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.3 | 7.9 | 0.0 |  | 22 | 0 | 606 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
2 x Pressfittingssystem MM | Havnivå | 0.3 | 7.7 | 0.2 |  | 22 | 0 | 2240 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1080 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 2 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1100 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1100 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 2 | Hydronic Supply |  |  | 320.004.04 Varme Tur 50° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå |  |  |  |  | 15 | 0 | 1080 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  |  | 320.003.05 Varme Retur 40° | MagiCAD Pset_Heating - sets with these values: 2
Pressfittingssystem MM | Havnivå | 0.3 | 7.4 | 0.7 | Cellegummi | 18 | 30 | 8528 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.3 | 36.8 | 0.6 | Cellegummi | 18 | 30 | 8428 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.2 | 0.0 |  | 15 | 0 | 108 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 8.2 | 0.0 |  | 15 | 0 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 8.3 | 0.0 | Cellegummi | 15 | 30 | 257 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 8.2 | 0.0 | Cellegummi | 15 | 30 | 370 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 36.0 | 0.1 | Cellegummi | 15 | 30 | 1419 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 8.2 | 0.1 | Cellegummi | 15 | 30 | 1579 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 7.3 | 0.1 | Cellegummi | 15 | 11 | 2402 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 7.2 | 0.0 | Cellegummi | 15 | 11 | 194 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 7.2 | 0.0 | Cellegummi | 15 | 11 | 2262 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.1 | 37.0 | 0.0 | Cellegummi | 15 | 30 | 493 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.1 | 7.2 | 0.0 | Cellegummi | 15 | 30 | 666 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.5 | 37.4 | 0.3 | Cellegummi | 42 | 30 | 1107 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.5 | 6.8 | 0.3 | Cellegummi | 42 | 30 | 1272 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.5 | 37.1 | 0.1 | Cellegummi | 42 | 30 | 1735 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.5 | 7.2 | 0.1 | Cellegummi | 42 | 30 | 1580 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.4 | 0.0 |  | 18 | 0 | 47 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.4 | 0.0 |  | 18 | 0 | 47 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.4 | 0.0 |  | 18 | 0 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply |  | MM | 320.004.04 Varme Tur 50°
Pressfittingssystem MM | Havnivå | 0.2 | 6.3 | 0.0 |  | 18 | 0 | 93 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return |  | MM | 320.003.05 Varme Retur 40°
Pressfittingssystem MM | Havnivå | 0.2 | 6.0 | 0.0 | Cellegummi | 22 | 30 | 325 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MM | 320.003.05 Varme Retur 40°
