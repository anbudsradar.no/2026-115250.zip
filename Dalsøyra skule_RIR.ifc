Properties of the parts of a building model (IFC2X3), part 5 of 14

# IfcCovering: BIB.021 (1891)
Name | In | MagiCAD Pset_Pipe, User Code | MagiCAD Pset_Pipe, Manufacturer | ConnectionSize_DN | Insulation_thickness_mm | SystemType | SystemName | SystemClass | MagiCAD Pset_Pipe, Insulation Material Code
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 40.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 438.07; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 3.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 158.07; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 3.9; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1171.333; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 40.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 964.493; Material Code: MM DN
2 x BIB.021 | Havnivå |  | Generic | 65-65-50 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 65-65-50; Insulation_thickness_mm [mm]: 30; National code: UB2; Insulation Material Code: Cellegummi; Description: MagiCAD - default T-branch
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 4.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1331.04; Material Code: MM DN
2 x BIB.021 | Havnivå |  | Generic | 65-65-50 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 65-65-50; Insulation_thickness_mm [mm]: 30; National code: UB2; Insulation Material Code: Cellegummi; Description: MagiCAD - default T-branch
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 40.2; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1537.879; Material Code: MM DN
BIB.021 | Havnivå |  | Generic | 65-65-32 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 65-65-32; Insulation_thickness_mm [mm]: 30; National code: UB2; Insulation Material Code: Cellegummi; Description: MagiCAD - default T-branch
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 4.0; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 11265.932; Material Code: MM DN
BIB.021 | Havnivå |  | Generic | 65-65-32 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Branch - Product variable 4: 2; ConnectionSize: 65-65-32; Insulation_thickness_mm [mm]: 30; National code: UB2; Insulation Material Code: Cellegummi; Description: MagiCAD - default T-branch
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 40.1; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 11065.932; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 54 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 4.5; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2706.082; Material Code: MM
BIB.021 | Havnivå |  | Standard | 54-50 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Reduction - Description: Single Socket Eccentric Reducer EN 1451-1; ConnectionSize: 54-50; Insulation_thickness_mm [mm]: 30; Insulation Material Code: Cellegummi; National code: UB2
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 4.4; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1989.552; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.5; pTot_SizingFlow_kPa [kPa]: 39.7; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1974.552; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 60.851; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1156.979; Material Code: MM
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 40.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 1019.206; Material Code: MM DN
BIB.021 | Havnivå | KRA.005 | Generic | 65 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 3.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN; MagiCAD Pset_Pipe - Material: Pressfittingssystem DN; Length_mm: 769.206; Material Code: MM DN
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.4; pTot_SizingFlow_kPa [kPa]: 9.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 201.627; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 35.3; dpTot_SizingFlow_kPa [kPa]: 25.3; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 202.931; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 35.7; dpTot_SizingFlow_kPa [kPa]: 26.8; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 9.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 263.086; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 35.7; dpTot_SizingFlow_kPa [kPa]: 26.4; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 296.53; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 27.4; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 36.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 120.01; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 36.0; dpTot_SizingFlow_kPa [kPa]: 27.7; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 259.022; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 35.9; dpTot_SizingFlow_kPa [kPa]: 27.2; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 242.19; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 36.4; dpTot_SizingFlow_kPa [kPa]: 28.2; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 523.163; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 36.8; dpTot_SizingFlow_kPa [kPa]: 28.7; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 194.498; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 36.4; dpTot_SizingFlow_kPa [kPa]: 28.1; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 517.595; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 36.1; dpTot_SizingFlow_kPa [kPa]: 27.5; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 9.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 346.764; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 35.5; dpTot_SizingFlow_kPa [kPa]: 26.2; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 8.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 343.27; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 35.7; dpTot_SizingFlow_kPa [kPa]: 27.0; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 144.897; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 36.8; dpTot_SizingFlow_kPa [kPa]: 29.3; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 39.26; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 37.8; dpTot_SizingFlow_kPa [kPa]: 31.1; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 199.459; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 37.0; dpTot_SizingFlow_kPa [kPa]: 29.6; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 71.179; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 37.2; dpTot_SizingFlow_kPa [kPa]: 30.0; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 37.3; dpTot_SizingFlow_kPa [kPa]: 30.2; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 30; pTot_SizingFlow_kPa [kPa]: 38.5; dpTot_SizingFlow_kPa [kPa]: 33.0; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 60.605; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 38.7; dpTot_SizingFlow_kPa [kPa]: 33.3; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 168.105; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 39.2; dpTot_SizingFlow_kPa [kPa]: 34.1; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 65.638; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 185.931; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 39.3; dpTot_SizingFlow_kPa [kPa]: 34.0; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 4.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 345.77; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 39.9; dpTot_SizingFlow_kPa [kPa]: 35.3; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 4.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 104.947; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 40.2; dpTot_SizingFlow_kPa [kPa]: 36.0; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 3.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 188.985; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 40.7; dpTot_SizingFlow_kPa [kPa]: 37.1; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 13.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 424.76; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 40.7; dpTot_SizingFlow_kPa [kPa]: 27.5; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 212.497; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 40.7; dpTot_SizingFlow_kPa [kPa]: 36.8; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 2.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 456.26; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 41.6; dpTot_SizingFlow_kPa [kPa]: 38.7; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 2.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 456.26; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 41.6; dpTot_SizingFlow_kPa [kPa]: 38.8; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 1.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1503.353; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 1.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2606.676; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 1.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 167.101; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 1.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 263.62; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 42.4; dpTot_SizingFlow_kPa [kPa]: 40.7; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 1.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 216.593; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 42.3; dpTot_SizingFlow_kPa [kPa]: 40.8; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 3.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 110.686; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 41.0; dpTot_SizingFlow_kPa [kPa]: 37.9; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 2.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 100.115; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 41.0; dpTot_SizingFlow_kPa [kPa]: 38.1; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 3.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 209.189; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 40.9; dpTot_SizingFlow_kPa [kPa]: 37.9; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 2.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 73.919; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 40.9; dpTot_SizingFlow_kPa [kPa]: 38.0; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 3.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 292.459; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 40.5; dpTot_SizingFlow_kPa [kPa]: 36.6; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 169.547; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 25-25 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 39.4; dpTot_SizingFlow_kPa [kPa]: 34.2; Product Code: TA-NANO Ext thread DN25 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 25
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 3.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 220.359; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 40.1; dpTot_SizingFlow_kPa [kPa]: 36.2; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 235.789; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 38.0; dpTot_SizingFlow_kPa [kPa]: 31.5; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 168.971; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 38.1; dpTot_SizingFlow_kPa [kPa]: 31.7; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 10.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 496.405; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 20-20 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 38.8; dpTot_SizingFlow_kPa [kPa]: 28.3; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 313.988; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 37.7; dpTot_SizingFlow_kPa [kPa]: 30.9; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 6.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 177.167; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 37.8; dpTot_SizingFlow_kPa [kPa]: 31.6; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 300.35; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 37.5; dpTot_SizingFlow_kPa [kPa]: 30.7; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 6.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 380.616; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 37.6; dpTot_SizingFlow_kPa [kPa]: 31.1; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 446.689; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 37.3; dpTot_SizingFlow_kPa [kPa]: 29.8; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 8.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 425.745; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 36.4; dpTot_SizingFlow_kPa [kPa]: 28.3; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
