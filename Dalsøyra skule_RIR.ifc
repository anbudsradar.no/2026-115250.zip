Properties of the parts of a building model (IFC2X3), part 10 of 14

# IfcFlowController: AT3600-40 (12)
Name | Group
7 x AT3600-40 | 320.003.05 Varme Retur 40°
4 x AT3600-40 | 320.003.04 Varme Tur 60°
AT3600-40 | 320.004.04 Varme Tur 50°

# IfcFlowController: AT3600-65
In: Havnivå
Type - Description: Kuleventil, kort spindel; PredefinedType: REGULATING
MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; User Code: SMA.001; NationalCode: UC1.30001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 0; Product Code: AT3600-65; ConnectionSize: 65-65
Group: 320.003.04 Varme Tur 60°

# IfcFlowController: AT3600-80 (12)
In: Havnivå
Type - Description: Kuleventil, kort spindel; PredefinedType: REGULATING
MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; User Code: SMA.001; NationalCode: UC1.30001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 30; Product Code: AT3600-80; ConnectionSize: 80-80
Name | Group
10 x AT3600-80 | 320.003.04 Varme Tur 60°
2 x AT3600-80 | 320.003.05 Varme Retur 40°

# IfcFlowController: FM-40
In: Havnivå
Type - Description: Vannmengdemåler; PredefinedType: FLOWMETER
MagiCAD Pset_PipeComponent - Description: Vannmengdemåler; Product variable 1: RFB; Product variable 2: 001; Product variable 4: 4; User Code: RFB.001; NationalCode: UD1; Manufacturer: General; ConnectionSize_mm: 40; Product Code: FM-40
Group: 320.003.05 Varme Retur 40°

# IfcFlowController: FM-65
In: Havnivå
Type - Description: Vannmengdemåler; PredefinedType: FLOWMETER
MagiCAD Pset_PipeComponent - Description: Vannmengdemåler; Product variable 1: RFB; Product variable 2: 001; Product variable 4: 4; User Code: RFB.001; NationalCode: UD1; Manufacturer: General; ConnectionSize_mm: 65; Product Code: FM-65
Group: 320.003.05 Varme Retur 40°

# IfcFlowController: FM-80
In: Havnivå
Type - Description: Vannmengdemåler; PredefinedType: FLOWMETER
MagiCAD Pset_PipeComponent - Description: Vannmengdemåler; Product variable 1: RFB; Product variable 2: 001; Product variable 4: 4; User Code: RFB.001; NationalCode: UD1; Manufacturer: General; ConnectionSize_mm: 65; Product Code: FM-80
Group: 320.003.05 Varme Retur 40°

# IfcFlowController: STAD/F-15/14 (3)
In: Havnivå
Type - Description: Innreguleringsventil DN 10-50; PredefinedType: REGULATING
MagiCAD Pset_Valve - Description: Innreguleringsventil DN 10-50; Product variable 1: SVZ; Product variable 2: 001; Product variable 4: 4; User Code: SVZ.001; NationalCode: UC2.123102112; Manufacturer: IMI Hydronic Engineering; Product Code: STAD/F-15/14; ConnectionSize: 15-15
Name | Insulation_thickness_mm [mm] | pTot_SizingFlow_kPa [kPa] | dpTot_SizingFlow_kPa [kPa] | Insulation Material Code | Group
STAD/F-15/14 | 12 | 5.3 | 4.5 | Cellegummi | 320.003.05 Varme Retur 40°
STAD/F-15/14 | 12 | 5.3 | 3.0 | Cellegummi | 320.003.05 Varme Retur 40°
STAD/F-15/14 | 0 |  |  |  | 312.002.01 VVC

# IfcFlowController: STAD/F-50
In: Havnivå
Type - Description: Innreguleringsventil DN 10-50; PredefinedType: REGULATING
MagiCAD Pset_Valve - Description: Innreguleringsventil DN 10-50; Product variable 1: SVZ; Product variable 2: 001; Product variable 4: 4; User Code: SVZ.001; NationalCode: UC2.123102112; Manufacturer: IMI Hydronic Engineering; Insulation_thickness_mm [mm]: 0; Product Code: STAD/F-50; ConnectionSize: 50-50
Group: 320.003.05 Varme Retur 40°

# IfcFlowController: TA-Modulator Slider 750 Plus PN16-DN65
In: Havnivå
Type - Description: PIBCV with Slider 750 Plus digitally configurable actuator
MagiCAD Pset_Valve - Description: PIBCV with Slider 750 Plus digitally configurable actuator; User Code: SBB501; Manufacturer: IMI; Insulation_thickness_mm [mm]: 0; Product Code: TA-Modulator Slider 750 Plus PN16-DN65; ConnectionSize: 65-65
Group: 320.003.05 Varme Retur 40°

# IfcFlowController: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V (27)
In: Havnivå
Type - Description: PIBCV, on/off, with normally open thermoelectric actuator
MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10
Group: 320.004.04 Varme Tur 50°
Name | Insulation_thickness_mm [mm] | pTot_SizingFlow_kPa [kPa] | dpTot_SizingFlow_kPa [kPa] | Insulation Material Code
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 35.7 | 26.8 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 35.9 | 27.4 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 36.0 | 27.7 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 35.9 | 27.2 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 35.7 | 27.0 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 37.3 | 30.2 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 30 | 38.5 | 33.0
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 38.7 | 33.3 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 42.4 | 40.7 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 42.3 | 40.8 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 41.0 | 37.9 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 41.0 | 38.1 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 40.9 | 37.9 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 40.9 | 38.0 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 40.5 | 36.6 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 40.1 | 36.2 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 37.7 | 30.9 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 37.8 | 31.6 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 37.6 | 31.1 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 38.1 | 32.3 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 30 | 37.5 | 30.6
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 38.5 | 32.7 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 36.9 | 29.6 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 35.9 | 27.5 | Cellegummi
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 42.2 | 40.5
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 42.4 | 41.1
TA-NANO Ext thread DN10 NF + EMO-T II NO 24V | 11 | 38.2 | 32.5

# IfcFlowController: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V (23)
Type - Description: PIBCV, on/off, with normally open thermoelectric actuator
MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15
Group: 320.004.04 Varme Tur 50°
Name | In | Insulation_thickness_mm [mm] | pTot_SizingFlow_kPa [kPa] | dpTot_SizingFlow_kPa [kPa] | Insulation Material Code
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 35.7 | 26.4 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 36.4 | 28.2 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 36.1 | 27.5 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 35.5 | 26.2 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 36.8 | 29.3 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 11 | 37.8 | 31.1 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 11 | 37.0 | 29.6 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 37.2 | 30.0 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 39.2 | 34.1 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 0 | 39.3 | 33.9
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 39.3 | 34.0 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 40.2 | 36.0 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 40.7 | 37.1 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 40.7 | 27.5 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 38.1 | 31.7 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 37.5 | 30.7 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 36.4 | 28.3 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 39.1 | 24.2 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 39.9 | 35.7 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 30 | 37.5 | 30.2
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 38.5 | 33.0 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Havnivå | 12 | 37.9 | 31.2 | Cellegummi
TA-NANO Ext thread DN15 NF + EMO-T II NO 24V | Plan U1 | 11 | 37.0 | 29.6 | Cellegummi

# IfcFlowController: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V (13)
Type - Description: PIBCV, on/off, with normally open thermoelectric actuator
MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi
Group: 320.004.04 Varme Tur 50°
Name | In | Insulation_thickness_mm [mm] | pTot_SizingFlow_kPa [kPa] | dpTot_SizingFlow_kPa [kPa]
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Havnivå | 12 | 35.3 | 25.3
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Havnivå | 12 | 36.8 | 28.7
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Havnivå | 12 | 36.4 | 28.1
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Havnivå | 12 | 39.9 | 35.3
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Havnivå | 12 | 40.7 | 36.8
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Havnivå | 12 | 41.6 | 38.7
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Havnivå | 12 | 41.6 | 38.8
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Havnivå | 12 | 38.0 | 31.5
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Havnivå | 13 | 38.8 | 28.3
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Havnivå | 12 | 37.3 | 29.8
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Havnivå | 12 | 36.4 | 27.8
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Havnivå | 12 | 36.6 | 28.2
TA-NANO Ext thread DN20 NF + EMO-T II NO 24V | Plan U1 | 13 | 37.2 | 30.2

# IfcFlowController: TA-NANO Ext thread DN25 NF + EMO-T II NO 24V (3)
In: Havnivå
Type - Description: PIBCV, on/off, with normally open thermoelectric actuator
MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 13; Product Code: TA-NANO Ext thread DN25 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi
Group: 320.004.04 Varme Tur 50°
Name | pTot_SizingFlow_kPa [kPa] | dpTot_SizingFlow_kPa [kPa]
TA-NANO Ext thread DN25 NF + EMO-T II NO 24V | 39.4 | 34.2
TA-NANO Ext thread DN25 NF + EMO-T II NO 24V | 36.5 | 27.5
TA-NANO Ext thread DN25 NF + EMO-T II NO 24V | 38.1 | 31.4

# IfcFlowController: Three-way mix. valve DN32
In: Havnivå
Type - Description: Three way mixing valve gunmetal without nipple
MagiCAD Pset_Valve - Description: Three way mixing valve gunmetal without nipple; User Code: SBB.002; Manufacturer: IMI; Insulation_thickness_mm [mm]: 0; Product Code: Three-way mix. valve DN32; ConnectionSize: 32-32-32
Group: 312.001.01 VV Forbruksvann

# IfcFlowController: Valve-with-motor-round-3w-DN40
In: Havnivå
Type - Description: 3-way Valve with motor, round body; PredefinedType: MIXING
MagiCAD Pset_Valve - Description: 3-way Valve with motor, round body; Product variable 1: SBA; Product variable 2: 006; Product variable 4: 4; User Code: SBA.006; NationalCode: UC2; Manufacturer: Generic; Insulation_thickness_mm [mm]: 0; Product Code: Valve-with-motor-round-3w-DN40; ConnectionSize: 40-40
Group: 320.003.04 Varme Tur 60°

# IfcFlowFitting: Mapress Bend (67)
In: Havnivå
Type - Description: Mapress CS Bend; PredefinedType: BEND
MagiCAD Pset_Elbow - Description: Mapress CS Bend
Name | ConnectionSize | Insulation_thickness_mm [mm] | Group
6 x Mapress Bend | 65-65 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
6 x Mapress Bend | 65-65 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
6 x Mapress Bend | 40-40 | 30 | 320.003.05 Varme Retur 40°
11 x Mapress Bend | 40-40 | 30 | 320.003.04 Varme Tur 60°
5 x Mapress Bend | 40-40 | 0 | 320.003.05 Varme Retur 40°
3 x Mapress Bend | 80-80 | 0 | 320.003.05 Varme Retur 40°
13 x Mapress Bend | 80-80 | 0 | 320.003.04 Varme Tur 60°
Mapress Bend | 20-20 | 0 | 320.003.04 Varme Tur 60°
4 x Mapress Bend | 20-20 | 0 | 320.003.05 Varme Retur 40°
4 x Mapress Bend | 65-65 | 0 | 320.003.05 Varme Retur 40°
2 x Mapress Bend | 40-40 | 0 | 320.003.04 Varme Tur 60°
Mapress Bend | 65-65 | 30 | 320.004.04 Varme Tur 50°
Mapress Bend | 32-32 | 0 | 320.004.04 Varme Tur 50°
3 x Mapress Bend | 32-32 | 0 | 320.003.05 Varme Retur 40°
Mapress Bend | 32-32 | 0 | 320.003.04 Varme Tur 60°

# IfcFlowFitting: Mapress Bend MM (463)
Type - Description: Mapress CS Bend; PredefinedType: BEND
MagiCAD Pset_Elbow - Description: Mapress CS Bend
Name | In | ConnectionSize | Insulation_thickness_mm [mm] | Group
2 x Mapress Bend MM | Havnivå | 35-35 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
17 x Mapress Bend MM | Havnivå | 22-22 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
10 x Mapress Bend MM | Havnivå | 28-28 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
16 x Mapress Bend MM | Havnivå | 22-22 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
19 x Mapress Bend MM | Havnivå | 18-18 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
17 x Mapress Bend MM | Havnivå | 18-18 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
17 x Mapress Bend MM | Havnivå | 22-22 | 0 | 320.003.05 Varme Retur 40°
17 x Mapress Bend MM | Havnivå | 22-22 | 0 | 320.004.04 Varme Tur 50°
18 x Mapress Bend MM | Havnivå | 22-22 | 30 | 320.004.04 Varme Tur 50°
12 x Mapress Bend MM | Havnivå | 18-18 | 30 | 320.004.04 Varme Tur 50°
11 x Mapress Bend MM | Havnivå | 18-18 | 30 | 320.003.05 Varme Retur 40°
14 x Mapress Bend MM | Havnivå | 18-18 | 0 | 320.004.04 Varme Tur 50°
14 x Mapress Bend MM | Havnivå | 18-18 | 0 | 320.003.05 Varme Retur 40°
34 x Mapress Bend MM | Havnivå | 15-15 | 0 | 320.004.04 Varme Tur 50°
34 x Mapress Bend MM | Havnivå | 15-15 | 0 | 320.003.05 Varme Retur 40°
40 x Mapress Bend MM | Havnivå | 15-15 | 30 | 320.004.04 Varme Tur 50°
34 x Mapress Bend MM | Havnivå | 15-15 | 30 | 320.003.05 Varme Retur 40°
18 x Mapress Bend MM | Havnivå | 15-15 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
18 x Mapress Bend MM | Havnivå | 15-15 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
10 x Mapress Bend MM | Havnivå | 28-28 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
Mapress Bend MM | Havnivå | 22-22 | 13 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
4 x Mapress Bend MM | Havnivå | 22-22 | 12 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
17 x Mapress Bend MM | Havnivå | 22-22 | 30 | 320.003.05 Varme Retur 40°
3 x Mapress Bend MM | Havnivå | 15-15 | 11 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
6 x Mapress Bend MM | Havnivå | 18-18 | 12 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
6 x Mapress Bend MM | Havnivå | 18-18 | 12 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
5 x Mapress Bend MM | Havnivå | 22-22 | 12 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
Mapress Bend MM | Havnivå | 28-28 | 13 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
Mapress Bend MM | Havnivå | 28-28 | 13 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
2 x Mapress Bend MM | Havnivå | 28-28 | 0 | 320.004.04 Varme Tur 50°
2 x Mapress Bend MM | Havnivå | 28-28 | 0 | 320.003.05 Varme Retur 40°
2 x Mapress Bend MM | Havnivå | 28-28 | 30 | 320.004.04 Varme Tur 50°
2 x Mapress Bend MM | Havnivå | 28-28 | 30 | 320.003.05 Varme Retur 40°
Mapress Bend MM | Havnivå | 35-35 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
Mapress Bend MM | Havnivå | 42-42 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
Mapress Bend MM | Havnivå | 42-42 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
3 x Mapress Bend MM | Havnivå | 15-15 | 11 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
8 x Mapress Bend MM | Havnivå | 42-42 | 30 | 320.003.04 Varme Tur 60°
8 x Mapress Bend MM | Havnivå | 42-42 | 30 | 320.003.05 Varme Retur 40°
3 x Mapress Bend MM | Havnivå | 42-42 | 0 | 320.003.05 Varme Retur 40°
3 x Mapress Bend MM | Plan U1 | 18-18 | 12 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
3 x Mapress Bend MM | Plan U1 | 18-18 | 12 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
3 x Mapress Bend MM | Plan U1 | 28-28 | 13 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
3 x Mapress Bend MM | Plan U1 | 28-28 | 13 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
Mapress Bend MM | Plan U1 | 28-28 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi
Mapress Bend MM | Plan U1 | 28-28 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Elbow - Insulation Material Code: Cellegummi

# IfcFlowFitting: Mapress Cap (2)
In: Havnivå
Type - Description: Mapress CS Plug; PredefinedType: OBSTRUCTION
MagiCAD Pset_Plug - Description: Mapress CS Plug; ConnectionSize: 80; Insulation_thickness_mm [mm]: 0; National code: UB3
Name | Group
Mapress Cap | 320.003.04 Varme Tur 60°
Mapress Cap | 320.003.05 Varme Retur 40°

# IfcFlowFitting: Mapress Coupling
In: Havnivå
Type - Description: Mapress CS Muffe; PredefinedType: CONNECTOR
MagiCAD Pset_Joint - Description: Mapress CS Muffe; ConnectionSize: 15-15; Insulation_thickness_mm [mm]: 30; National code: UB3
Group: 320.004.04 Varme Tur 50°

# IfcFlowFitting: Mapress Reducer with plain end MM (48)
Type - Description: Mapress CS Overgang; PredefinedType: TRANSITION
MagiCAD Pset_Reduction - Description: Mapress CS Overgang
Name | In | ConnectionSize | Insulation_thickness_mm [mm] | Insulation Material Code | Group
3 x Mapress Reducer with plain end MM | Havnivå | 18-15 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
3 x Mapress Reducer with plain end MM | Havnivå | 18-15 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
3 x Mapress Reducer with plain end MM | Havnivå | 22-18 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
3 x Mapress Reducer with plain end MM | Havnivå | 22-18 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
4 x Mapress Reducer with plain end MM | Havnivå | 35-28 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
3 x Mapress Reducer with plain end MM | Havnivå | 35-28 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
2 x Mapress Reducer with plain end MM | Havnivå | 28-18 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
3 x Mapress Reducer with plain end MM | Havnivå | 28-18 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
4 x Mapress Reducer with plain end MM | Havnivå | 28-22 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
5 x Mapress Reducer with plain end MM | Havnivå | 28-22 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
2 x Mapress Reducer with plain end MM | Havnivå | 42-35 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
2 x Mapress Reducer with plain end MM | Havnivå | 42-35 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
Mapress Reducer with plain end MM | Havnivå | 35-22 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
Mapress Reducer with plain end MM | Havnivå | 35-22 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
Mapress Reducer with plain end MM | Havnivå | 28-15 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
Mapress Reducer with plain end MM | Havnivå | 54-42 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
Mapress Reducer with plain end MM | Havnivå | 22-18 | 30 |  | 320.004.04 Varme Tur 50°
Mapress Reducer with plain end MM | Havnivå | 54-42 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
2 x Mapress Reducer with plain end MM | Havnivå | 22-15 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
Mapress Reducer with plain end MM | Havnivå | 22-15 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
Mapress Reducer with plain end MM | Plan U1 | 28-18 | 13 | Cellegummi | 320.003.05 Varme Retur 40°
Mapress Reducer with plain end MM | Plan U1 | 28-18 | 13 | Cellegummi | 320.004.04 Varme Tur 50°

# IfcFlowFitting: Reducer-EN1451-1-4_NOR
In: Havnivå
Type - Description: Single Socket Eccentric Reducer EN 1451-1; PredefinedType: TRANSITION
MagiCAD Pset_Reduction - Description: Single Socket Eccentric Reducer EN 1451-1; ConnectionSize: 54-50; Insulation_thickness_mm [mm]: 30; National code: UB2; Insulation Material Code: Cellegummi
Group: 320.003.05 Varme Retur 40°

# IfcFlowFitting: magi_pipe_cu_elbow_short_NOR (22)
In: Havnivå
Type - Description: MagiCAD - default bend; PredefinedType: BEND
MagiCAD Pset_Elbow - Description: MagiCAD - default bend; Product variable 4: 2
Name | ConnectionSize | Insulation_thickness_mm [mm] | Group
6 x magi_pipe_cu_elbow_short_NOR | 35-35 | 0 | 311.001.01 KV Forbruksvann
7 x magi_pipe_cu_elbow_short_NOR | 35-35 | 30 | 312.001.01 VV Forbruksvann
6 x magi_pipe_cu_elbow_short_NOR | 15-15 | 30 | 312.002.01 VVC
3 x magi_pipe_cu_elbow_short_NOR | 42-42 | 0 | 311.001.01 KV Forbruksvann

# IfcFlowFitting: magi_pipe_cu_plug_001 (4)
In: Havnivå
Type - Description: MagiCAD - default plug; PredefinedType: OBSTRUCTION
MagiCAD Pset_Plug - Description: MagiCAD - default plug; Product variable 4: 2; National code: UB1
Name | ConnectionSize | Insulation_thickness_mm [mm]
2 x magi_pipe_cu_plug_001 | 12 | 30
magi_pipe_cu_plug_001 | 42 | 0 | Group: 320.003.04 Varme Tur 60°
magi_pipe_cu_plug_001 | 42 | 0 | Group: 320.003.05 Varme Retur 40°

# IfcFlowFitting: magi_pipe_cu_reducer_centric_short_NOR (301)
Type - PredefinedType: TRANSITION
MagiCAD Pset_Reduction - Product variable 4: 2; National code: UB1
Name | In | ConnectionSize | Insulation_thickness_mm [mm] | Group
3 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 18-15 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 18-15 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 28-22 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 50-42 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 32-28 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 32-28 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 50-42 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
4 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 20-18 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
4 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 20-18 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
6 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 25-22 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
6 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 25-22 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 28-18 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 28-22 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 22-18 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 22-18 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 42-35 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 42-35 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 28-18 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 28-15 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 54-50 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
6 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 28-25 | 30 | 320.004.04 Varme Tur 50°
32 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 18-15 | 30 | 320.004.04 Varme Tur 50°
24 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 22-20 | 30 | 320.004.04 Varme Tur 50°
12 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 15-12 | 30 | 320.004.04 Varme Tur 50°
9 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 42-40 | 30 | 320.003.04 Varme Tur 60°
9 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 42-40 | 30 | 320.003.05 Varme Retur 40°
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 42-32 | 30 | 320.003.05 Varme Retur 40°
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 42-32 | 0 | 320.003.05 Varme Retur 40°
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 55-35 | 30 | 312.001.01 VV Forbruksvann
6 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 42-40 | 0 | 320.003.05 Varme Retur 40°
10 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 18-15 | 0 | 320.004.04 Varme Tur 50°
10 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 18-15 | 0 | 320.003.05 Varme Retur 40°
5 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 18-15 | 12 | 320.004.04 Varme Tur 50°
5 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 18-15 | 12 | 320.003.05 Varme Retur 40°
9 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 35-32 | 30 | 312.001.01 VV Forbruksvann
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 32-15 | 30 | 312.002.01 VVC
3 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 35-32 | 0 | 311.001.01 KV Forbruksvann
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 42-35 | 0 | 311.001.01 KV Forbruksvann
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 42-40 | 0 | 320.003.04 Varme Tur 60°
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 22-15 | 12 | 320.004.04 Varme Tur 50°
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 22-15 | 12 | 320.003.05 Varme Retur 40°
13 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 22-15 | 0 | 320.003.05 Varme Retur 40°
4 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 22-20 | 30 | 320.003.05 Varme Retur 40°
13 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 22-15 | 0 | 320.004.04 Varme Tur 50°
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 28-15 | 13 | 320.004.04 Varme Tur 50°
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 28-15 | 13 | 320.003.05 Varme Retur 40°
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 28-15 | 0 | 320.004.04 Varme Tur 50°
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 28-15 | 0 | 320.003.05 Varme Retur 40°
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 35-28 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 35-28 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
4 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 18-15 | 30 | 320.003.05 Varme Retur 40°
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 22-20 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 22-20 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
12 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 22-15 | 30 | 320.004.04 Varme Tur 50°
2 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 28-20 | 30 | 320.004.04 Varme Tur 50°
36 x magi_pipe_cu_reducer_centric_short_NOR | Havnivå | 15-10 | 30 | 320.004.04 Varme Tur 50°
magi_pipe_cu_reducer_centric_short_NOR | Plan U1 | 42-25 | 0 | 311.001.01 KV Forbruksvann
magi_pipe_cu_reducer_centric_short_NOR | Plan U1 | 35-25 | 0 | 311.001.01 KV Forbruksvann
2 x magi_pipe_cu_reducer_centric_short_NOR | Plan U1 | 18-15 | 12 | 320.004.04 Varme Tur 50°
2 x magi_pipe_cu_reducer_centric_short_NOR | Plan U1 | 28-20 | 13 | 320.004.04 Varme Tur 50°

# IfcFlowFitting: magi_pipe_cu_tee_centric_90_NOR (120)
Type - PredefinedType: JUNCTION
MagiCAD Pset_Branch - Product variable 4: 2; National code: UB1
Name | In | ConnectionSize | Insulation_thickness_mm [mm] | Insulation Material Code | Group
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 54-54-42 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 54-54-42 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
2 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 42-42-22 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
2 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 42-42-22 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
4 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 42-42-28 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
4 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 42-42-28 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 35-35-35 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
2 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 35-35-35 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
5 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 28-28-22 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
5 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 28-28-22 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
2 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 35-35-18 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
2 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 35-35-18 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
2 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 42-42-18 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
2 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 42-42-18 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 22-22-18 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 22-22-18 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 15-15-15 | 30 |  | 320.004.04 Varme Tur 50°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 15-15-15 | 30 |  | 320.003.05 Varme Retur 40°
6 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 15-15-15 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
6 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 15-15-15 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
3 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 28-28-18 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
3 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 28-28-18 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
6 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 22-22-15 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
5 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 22-22-15 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
4 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 18-18-15 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
4 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 18-18-15 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
7 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 42-42-15 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
7 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 42-42-15 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
2 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 35-35-22 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
2 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 35-35-22 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 22-22-15 | 30 |  | 320.003.05 Varme Retur 40°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 22-22-15 | 30 |  | 320.004.04 Varme Tur 50°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 22-22-22 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 54-54-18 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 54-54-18 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 28-28-15 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 28-28-15 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
4 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 35-35-28 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
3 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 35-35-28 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
2 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 28-28-28 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
2 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 28-28-28 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 15-15-15 | 30 |  | 312.002.01 VVC
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 35-35-15 | 0 |  | 311.001.01 KV Forbruksvann
2 x magi_pipe_cu_tee_centric_90_NOR | Havnivå | 35-35-35 | 0 |  | 312.001.01 VV Forbruksvann
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 42-42-35 | 0 |  | 311.001.01 KV Forbruksvann
magi_pipe_cu_tee_centric_90_NOR | Havnivå | 42-42-42 | 0 |  | 311.001.01 KV Forbruksvann
magi_pipe_cu_tee_centric_90_NOR | Plan U1 | 28-28-28 | 13 | Cellegummi | 320.004.04 Varme Tur 50°
magi_pipe_cu_tee_centric_90_NOR | Plan U1 | 28-28-28 | 13 | Cellegummi | 320.003.05 Varme Retur 40°

# IfcFlowFitting: magi_pipe_fe_reducer_centric_short_001 (41)
In: Havnivå
Type - Description: MagiCAD - default reduction; PredefinedType: TRANSITION
MagiCAD Pset_Reduction - Description: MagiCAD - default reduction; National code: UB3
Name | ConnectionSize | Insulation_thickness_mm [mm] | Group
magi_pipe_fe_reducer_centric_short_001 | 65-50 | 30 | 320.003.05 Varme Retur 40° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
magi_pipe_fe_reducer_centric_short_001 | 65-50 | 30 | 320.004.04 Varme Tur 50° | MagiCAD Pset_Reduction - Insulation Material Code: Cellegummi
4 x magi_pipe_fe_reducer_centric_short_001 | 15-10 | 30 | 320.004.04 Varme Tur 50°
3 x magi_pipe_fe_reducer_centric_short_001 | 65-50 | 0 | 320.003.05 Varme Retur 40°
6 x magi_pipe_fe_reducer_centric_short_001 | 40-32 | 0 | 320.003.05 Varme Retur 40°
2 x magi_pipe_fe_reducer_centric_short_001 | 40-32 | 0 | 320.003.04 Varme Tur 60°
magi_pipe_fe_reducer_centric_short_001 | 42-40 | 30 | 320.003.05 Varme Retur 40°
4 x magi_pipe_fe_reducer_centric_short_001 | 42-40 | 30 | 320.003.04 Varme Tur 60°
3 x magi_pipe_fe_reducer_centric_short_001 | 42-40 | 0 | 320.003.05 Varme Retur 40°
3 x magi_pipe_fe_reducer_centric_short_001 | 40-32 | 0 | 320.004.04 Varme Tur 50°
magi_pipe_fe_reducer_centric_short_001 | 55-40 | 0 | 320.003.05 Varme Retur 40°
magi_pipe_fe_reducer_centric_short_001 | 80-42 | 0 | 320.003.05 Varme Retur 40°
2 x magi_pipe_fe_reducer_centric_short_001 | 80-50 | 30 | 320.003.04 Varme Tur 60°
6 x magi_pipe_fe_reducer_centric_short_001 | 80-65 | 30 | 320.003.04 Varme Tur 60°
magi_pipe_fe_reducer_centric_short_001 | 80-42 | 30 | 320.003.04 Varme Tur 60°
magi_pipe_fe_reducer_centric_short_001 | 80-65 | 30 | 320.003.05 Varme Retur 40°
magi_pipe_fe_reducer_centric_short_001 | 12-10 | 30 | 320.004.04 Varme Tur 50°

# IfcFlowFitting: magi_pipe_fe_tee_centric_90_NOR (49)
In: Havnivå
Type - Description: MagiCAD - default T-branch; PredefinedType: JUNCTION
MagiCAD Pset_Branch - Description: MagiCAD - default T-branch; Product variable 4: 2; National code: UB2
Name | ConnectionSize | Insulation_thickness_mm [mm] | Insulation Material Code | Group
6 x magi_pipe_fe_tee_centric_90_NOR | 65-65-25 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
6 x magi_pipe_fe_tee_centric_90_NOR | 65-65-25 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
4 x magi_pipe_fe_tee_centric_90_NOR | 65-65-20 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
4 x magi_pipe_fe_tee_centric_90_NOR | 65-65-20 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
3 x magi_pipe_fe_tee_centric_90_NOR | 65-65-15 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
3 x magi_pipe_fe_tee_centric_90_NOR | 65-65-15 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
2 x magi_pipe_fe_tee_centric_90_NOR | 65-65-50 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
2 x magi_pipe_fe_tee_centric_90_NOR | 65-65-50 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
magi_pipe_fe_tee_centric_90_NOR | 65-65-32 | 30 | Cellegummi | 320.003.05 Varme Retur 40°
magi_pipe_fe_tee_centric_90_NOR | 65-65-32 | 30 | Cellegummi | 320.004.04 Varme Tur 50°
magi_pipe_fe_tee_centric_90_NOR | 40-40-40 | 0 |  | 320.003.05 Varme Retur 40°
magi_pipe_fe_tee_centric_90_NOR | 80-80-80 | 0 |  | 320.003.05 Varme Retur 40°
magi_pipe_fe_tee_centric_90_NOR | 80-80-40 | 0 |  | 320.003.05 Varme Retur 40°
4 x magi_pipe_fe_tee_centric_90_NOR | 80-80-80 | 0 |  | 320.003.04 Varme Tur 60°
magi_pipe_fe_tee_centric_90_NOR | 80-80-20 | 0 |  | 320.003.04 Varme Tur 60°
magi_pipe_fe_tee_centric_90_NOR | 20-20-20 | 0 |  | 320.003.04 Varme Tur 60°
3 x magi_pipe_fe_tee_centric_90_NOR | 80-80-20 | 0 |  | 320.003.05 Varme Retur 40°
magi_pipe_fe_tee_centric_90_NOR | 80-80-65 | 0 |  | 320.003.04 Varme Tur 60°
magi_pipe_fe_tee_centric_90_NOR | 80-80-65 | 0 |  | 320.003.05 Varme Retur 40°
magi_pipe_fe_tee_centric_90_NOR | 80-80-42 | 0 |  | 320.003.04 Varme Tur 60°
magi_pipe_fe_tee_centric_90_NOR | 80-80-42 | 0 |  | 320.003.05 Varme Retur 40°
magi_pipe_fe_tee_centric_90_NOR | 80-80-40 | 0 |  | 320.003.04 Varme Tur 60°

# IfcFlowMovingDevice: MAGNA3 32-100 F PN6 - 97924258 (2)
In: Havnivå
Type - Description: Single head circulator in cast iron
MagiCAD Pset_Pump - Description: Single head circulator in cast iron; User Code: JPA.001; Manufacturer: Grundfos; Product Code: MAGNA3 32-100 F PN6 - 97924258
Group: 320.003.05 Varme Retur 40°

# IfcFlowMovingDevice: MAGNA3 65-150 F PN6 - 99424868 (2)
In: Havnivå
Type - Description: Single head circulator in cast iron
MagiCAD Pset_Pump - Description: Single head circulator in cast iron; User Code: JPA.001; Manufacturer: Grundfos; Product Code: MAGNA3 65-150 F PN6 - 99424868
Group: 320.003.04 Varme Tur 60°

# IfcFlowMovingDevice: UP 15-14 B PM
In: Havnivå
Type - Description: Energy efficient circulator - stainless steel
MagiCAD Pset_Pump - Description: Energy efficient circulator - stainless steel; User Code: JPA.003; Manufacturer: Grundfos; Product Code: UP 15-14 B PM
Group: 312.002.01 VVC

# IfcFlowSegment: Kobberrør (48)
In: Havnivå
Type - Description: Kobberrør; PredefinedType: RIGIDSEGMENT
Material: Cu 0 mm
MagiCAD Pset_Heating - Material Code: Cu; sets with these values: 2
MagiCAD Pset_Pipe - User Code: KRA.001; Product variable 5: 7; Product variable 4: 2; Product variable 3: mm; Product variable 2: 001; Product variable 1: KRA; NationalCode: UB1.1105100000; Description: Kobberrør; Material Code: Cu
Name | Material | ConnectionSize_DN | Insulation_thickness_mm [mm] | Length_mm | SystemType = Group | SystemName | SystemClass
Kobberrør | Kobberrør | 35 | 30 | 18 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 1 | Domestic Hot Water
Kobberrør | Kobberrør | 35 | 0 | 47 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 35 | 30 | 1776 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 1 | Domestic Hot Water
Kobberrør | Kobberrør | 35 | 30 | 39 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 1 | Domestic Hot Water
Kobberrør | <By Category> | 55 | 30 | 19 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 15 | 30 | 42 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 15 | 30 | 408 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 15 | 30 | 173 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 15 | 30 | 29 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 35 | 0 | 134 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 15 | 30 | 290 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 35 | 30 | 26 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 35 | 30 | 73 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 35 | 0 | 51 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 15 | 30 | 423 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 15 | 30 | 570 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 35 | 30 | 358 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 42 | 0 | 1288 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 35 | 0 | 353 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 42 | 0 | 552 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 35 | 0 | 1027 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 35 | 30 | 800 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 15 | 30 | 1370 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 15 | 30 | 325 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 35 | 30 | 477 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 15 | 30 | 160 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 35 | 0 | 74 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 15 | 30 | 19 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 15 | 30 | 73 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 35 | 0 | 89 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 35 | 0 | 574 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 35 | 0 | 451 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 15 | 30 | 41 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 35 | 30 | 12 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 35 | 30 | 76 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 35 | 30 | 92 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 35 | 30 | 8 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 35 | 30 | 155 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 35 | 30 | 69 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 35 | 30 | 86 | 312.001.01 VV Forbruksvann | 312.001.01 VV Forbruksvann 2 | Domestic Hot Water
Kobberrør | Kobberrør | 15 | 30 | 58 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 15 | 30 | 33 | 312.002.01 VVC | 312.002.01 VVC 1 | Hydronic Return
Kobberrør | Kobberrør | 35 | 0 | 44 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 42 | 0 | 1608 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 42 | 0 | 239 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 42 | 0 | 1040 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 42 | 0 | 201 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water
Kobberrør | Kobberrør | 35 | 0 | 81 | 311.001.01 KV Forbruksvann | 311.001.01 KV Forbruksvann 1 | Domestic Cold Water

# IfcFlowSegment: PVC grunnavløpsrør
In: Havnivå
Type - Description: PVC grunnavløpsrør; PredefinedType: RIGIDSEGMENT
Material: PVC 0 mm; Group: 314.001.01 Spillvann
MagiCAD Pset_Heating - Material Code: PVC; sets with these values: 2
MagiCAD Pset_Pipe - User Code: KNA.005; Product variable 5: 2; Product variable 4: 2; Product variable 3: mm; Product variable 2: 005; Manufacturer: Standard; Material: PVC grunnavløpsrør; Product variable 1: KNA; NationalCode: UB2.1121111111; ConnectionSize_DN: 75; Insulation_thickness_mm [mm]: 0; Length_mm: 280; SystemType: 314.001.01 Spillvann; Description: PVC grunnavløpsrør; SystemName: 314.001.01 Spillvann 1; SystemClass: Sanitary; Material Code: PVC

# IfcFlowSegment: Pressfittingssystem DN (166)
In: Havnivå
Type - Description: Pressfittingssystem DN EN-10305; PredefinedType: RIGIDSEGMENT
Material: MM DN 0 mm
MagiCAD Pset_Heating - Material Code: MM DN
MagiCAD Pset_Pipe - User Code: KRA.005; Product variable 5: 2; Product variable 4: 2; Product variable 2: 005; Manufacturer: Generic; Material: Pressfittingssystem DN; Product variable 1: KRA; NationalCode: UB3.11004400022; Insulation_thickness_mm [mm]: 30; Description: Pressfittingssystem DN EN-10305; Material Code: MM DN
Name | ConnectionSize_DN | Length_mm | SystemType = Group | SystemName | SystemClass | sets with these values
Pressfittingssystem DN | 65 | 162 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 42.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 5729 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 42.7; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 107 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 40.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 6029 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 1.2; dpTot_SizingFlow_kPa [kPa]: 0.5; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 50 | 100 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 4.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 50 | 120 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 39.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 347 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 3.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 625 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 42.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 425 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 1.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 11559 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 1.7; dpTot_SizingFlow_kPa [kPa]: 0.8; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 11359 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 42.3; dpTot_SizingFlow_kPa [kPa]: 0.8; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 162 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.8; pTot_SizingFlow_kPa [kPa]: 1.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 2172 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 41.5; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 2172 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 2.6; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1423 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 41.4; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1423 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 2.7; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1291 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 41.3; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1071 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 2.8; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 2834 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 2.9; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 2810 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 41.2; dpTot_SizingFlow_kPa [kPa]: 0.2; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 6613 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 40.9; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 6663 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 3.2; dpTot_SizingFlow_kPa [kPa]: 0.4; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1573 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 3.1; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1377 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 41.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1077 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 40.4; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1077 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.7; pTot_SizingFlow_kPa [kPa]: 3.7; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 438 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 40.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 158 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 3.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1171 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 3.9; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 964 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 40.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
Pressfittingssystem DN | 65 | 1331 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.6; pTot_SizingFlow_kPa [kPa]: 4.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Insulation Material Code: Cellegummi; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM DN
