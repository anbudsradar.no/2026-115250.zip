Properties of the parts of a building model (IFC2X3), part 6 of 14

# IfcCovering: BIB.021 (1891)
Name | In | MagiCAD Pset_Pipe, User Code | MagiCAD Pset_Pipe, Manufacturer | ConnectionSize_DN | Insulation_thickness_mm | SystemType | SystemName | SystemClass | MagiCAD Pset_Pipe, Insulation Material Code
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 8.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 302.456; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 36.4; dpTot_SizingFlow_kPa [kPa]: 27.8; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 36.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 91.542; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 36.6; dpTot_SizingFlow_kPa [kPa]: 28.2; Product Code: TA-NANO Ext thread DN20 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 20
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 9.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 254.001; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 25-25 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 36.5; dpTot_SizingFlow_kPa [kPa]: 27.5; Product Code: TA-NANO Ext thread DN25 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 25
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 251.024; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 38.1; dpTot_SizingFlow_kPa [kPa]: 32.3; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 309.798; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 25-25 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 38.1; dpTot_SizingFlow_kPa [kPa]: 31.4; Product Code: TA-NANO Ext thread DN25 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 25
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 14.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 664.217; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 39.1; dpTot_SizingFlow_kPa [kPa]: 24.2; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 4.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 166.183; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 39.9; dpTot_SizingFlow_kPa [kPa]: 35.7; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 17.322; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 30; pTot_SizingFlow_kPa [kPa]: 37.5; dpTot_SizingFlow_kPa [kPa]: 30.6; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 7.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 96.964; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 15-15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 30; pTot_SizingFlow_kPa [kPa]: 37.5; dpTot_SizingFlow_kPa [kPa]: 30.2; Product Code: TA-NANO Ext thread DN15 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 15; ConnectionSize: 15-15; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 15
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 177.022; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 6.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 37.652; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 116.364; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 27.497; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 215.927; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 6.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 90; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 517.046; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 72.893; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.4; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 697.046; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 799.907; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 750.255; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 39.345; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 37.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 127.158; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 37.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 40.98; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 228.21; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 37.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 7.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 488.184; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 11 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 7.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 6.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 78.898; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 15-15 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 37.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-15; ConnectionSize: 15-15; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 289.931; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 34.961; Material Code: MM
BIB.021 | Havnivå | SPZ.001 | IMI | 10-10 | 11 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply,Power | Cellegummi | MagiCAD Pset_Valve - Description: PIBCV, on/off, with normally open thermoelectric actuator; User Code: SPZ.001; Manufacturer: IMI; Insulation_thickness_mm [mm]: 11; pTot_SizingFlow_kPa [kPa]: 38.5; dpTot_SizingFlow_kPa [kPa]: 32.7; Product Code: TA-NANO Ext thread DN10 NF + EMO-T II NO 24V; Object Variable 1: Aktuatorventil DN 10; ConnectionSize: 10-10; Insulation Material Code: Cellegummi; MagiCAD Pset_Pipe - Object Variable 1: Aktuatorventil DN 10
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 92.977; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 38.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 55.074; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 51.719; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 38.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 98.328; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 160.938; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 39.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 72.355; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 4.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Material Code: MM; MagiCAD Pset_Water - Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 93.542; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 4.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 333.139; Material Code: MM
2 x BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 4.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 39.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 138.889; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 39.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 39.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 258.808; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 39.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 564.718; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 3.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 40.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 133.043; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 40.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 165.083; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 3.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 40.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 270.967; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 3.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 502.213; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 40.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 208.87; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.0; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 864.439; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 3.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 446.874; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 3.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 40.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 233.715; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 40.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 41.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 509.629; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 41.6; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 2.1; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 938.407; Material Code: MM
2 x BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 2.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 2.1; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1022.076; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 41.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 546.815; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 41.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 1.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1363.249; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 1.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 2506.676; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 1.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 267.101; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 1.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 526.412; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 42.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 201.772; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 1.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 467.661; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 41.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 164.069; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 2.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 172.789; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 2.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 118.928; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 41.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 143.508; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 2.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 94.947; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 40.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 177.799; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 40.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 107.762; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 2.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 413.095; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 40.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 153.176; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 3.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 572.83; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 3.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 399.079; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 39.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 293.467; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 25-25 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 39.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 4.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 660.222; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 25-25 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 4.4; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 39.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 100.198; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 4.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 369.535; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 39.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 213.645; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 39.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 4.7; dpTot_SizingFlow_kPa [kPa]: 0.1; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 1124.97; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 38.5; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 181.678; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 192.5; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 38.1; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 149.101; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 18 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 442.225; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 5.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 447.301; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 5.9; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 22 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.3; pTot_SizingFlow_kPa [kPa]: 38.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 169.72; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 20-20 | 12 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 12; pTot_SizingFlow_kPa [kPa]: 38.0; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-20; ConnectionSize: 20-20; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 223.16; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 5.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 123.16; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 5.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 807.185; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 25-25 | 13 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 5.2; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 28 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 38.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 147.819; Material Code: MM
BIB.021 | Havnivå | SMA.001 | Armatec | 25-25 | 13 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Valve - Description: Kuleventil, kort spindel; User Code: SMA.001; Manufacturer: Armatec; Insulation_thickness_mm [mm]: 13; pTot_SizingFlow_kPa [kPa]: 38.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Product Code: AT3600-25; ConnectionSize: 25-25; Insulation Material Code: Cellegummi; Product variable 1: SMA; Product variable 2: 001; Product variable 4: 4; NationalCode: UC1.30001
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.003.05 Varme Retur 40° | 320.003.05 Varme Retur 40° 1 | Hydronic Return | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 6.3; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 521.484; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.2; pTot_SizingFlow_kPa [kPa]: 37.7; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 164.649; Material Code: MM
BIB.021 | Havnivå | KRA.004 | Generic | 15 | 30 | 320.004.04 Varme Tur 50° | 320.004.04 Varme Tur 50° 3 | Hydronic Supply | Cellegummi | MagiCAD Pset_Heating - v_SizingFlow_ms [m/s]: 0.1; pTot_SizingFlow_kPa [kPa]: 37.8; dpTot_SizingFlow_kPa [kPa]: 0.0; Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Water - Insulation Material Code: Cellegummi; Material Code: MM; MagiCAD Pset_Pipe - Material: Pressfittingssystem MM; Length_mm: 135.728; Material Code: MM
